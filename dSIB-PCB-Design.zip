# Allegro board DSIB_REV3_1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SJ4_LM_DOWN_B: length 126.4
  TOP w0.127: v1(101.73,123.95) 100.46,123.95 v1(100.08,123.57) ; J14.149 118.62,34.67 v1(103.12,34.67) ; v1(100.08,97.92) 100.08,97.54 99.31,96.77 99.31,93.85 101.85,91.31 v1(101.85,87)
  BOTTOM w0.127: v1(103.12,34.67) 103.12,59.44 102.62,59.94 102.62,64.52 102.87,64.77 102.87,68.07 102.62,68.33 102.62,83.31 101.85,84.07 v1(101.85,87) ; 97.23,132.64 97.28,132.69 ; 97.28,132.69 97.28,132.84 97.66,133.22 100.33,133.22 101.35,132.21 101.35,127.38 101.73,127 v1(101.73,123.95) ; 97.28,132.69 R82.2 ; J14.149 C128.1 ; v1(100.08,123.57) v1(100.08,97.92)
SJ4_LM_GND_SENSEN: length 205
  TOP w0.127: v1(96.77,126.37) 96.9,126.24 100.58,126.24 100.84,126.49 v1(101.22,126.49) ; v1(100.84,101.6) 101.09,101.35 105.92,101.35 106.05,101.47 110.74,101.47 110.87,101.35 v1(155.96,101.35) ; v1(155.96,65.53) 153.92,65.53 153.8,65.66 152.91,65.66 152.02,64.77 135.89,64.77 135.38,65.28 133.48,65.28 133.22,65.02 v1(123.95,65.02)
  BOTTOM w0.127: 97.25,127.85 U19.5 97.16,128.42 97.16,127.76 96.77,127.38 96.77,127.37 97.25,127.85 ; 97.25,127.85 97.25,127.63 97.16,127.63 96.77,127.25 v1(96.77,126.37) ; v1(155.96,101.35) v1(155.96,65.53) ; 100.97,126.62 100.97,124.33 100.84,124.21 v1(100.84,101.6) ; 100.97,126.62 101.09,126.49 v1(101.22,126.49) ; 100.97,126.62 100.97,130.94 100.58,131.32 99.57,131.32 98.68,132.21 98.04,132.21 97.75,131.92 U19.11 ; J14.150 122.05,31.24 122.07,31.34 R86.2 123.52,31.88 123.57,31.88 123.57,46.23 123.95,46.61 v1(123.95,65.02)
SJ4_LM_UP: length 38.9
  TOP w0.127: v1(64.26,128.78) 64.13,128.91 64.39,128.91 64.77,129.29 74.68,129.29 75.31,128.65 90.17,128.65 90.93,129.41 v1(94.49,129.41)
  BOTTOM w0.127: J16.9 64.59,129.11 v1(64.26,128.78) ; U19.6 96.27,128.42 96.27,128.4 95.12,128.4 94.74,128.78 94.74,129.16 v1(94.49,129.41)
SJ4_LM_UP_A: length 172.3
  TOP w0.127: J14.144 131.83,46.48 134.75,43.56 153.42,43.56 155.07,45.21 155.07,49.28 155.57,49.78 157.1,49.78 160.27,52.96 160.27,57.66 v1(159.38,58.55) ; v1(114.05,109.98) 147.19,109.98 147.7,109.47 v1(158.75,109.47)
  BOTTOM w0.127: v1(158.75,109.47) 158.75,94.49 159.13,94.11 159.13,60.2 159.26,60.07 159.26,58.67 v1(159.38,58.55) ; 115.06,128.65 R79.2 ; 115.06,128.65 115.06,121.92 114.94,121.79 114.94,114.43 114.81,114.3 114.43,114.3 113.92,113.79 113.92,110.11 v1(114.05,109.98) ; 115.06,128.65 113.86,128.65 113.66,128.84 U18.13
SJ4_LM_UP_B: length 183.3
  TOP w0.127: v1(96.65,124.71) 97.66,125.73 104.39,125.73 104.65,125.98 105.66,125.98 106.43,125.22 111.25,125.22 114.05,122.43 v1(157.1,122.43) ; v1(120.65,59.94) 120.9,60.2 154.69,60.2 155.19,60.71 v1(157.73,60.71)
  BOTTOM w0.127: J14.145 120.4,43.94 120.65,44.2 v1(120.65,59.94) ; 97.66,126.59 97.66,126.49 96.9,125.73 96.9,124.97 v1(96.65,124.71) ; 97.66,126.59 R92.2 ; 97.66,126.59 97.66,127.63 97.75,127.63 U19.4 ; v1(157.1,122.43) 157.1,117.47 157.73,116.84 157.73,111 157.48,110.74 157.48,109.22 157.73,108.97 v1(157.73,60.71)
SJ4_POT1: length 62.3
  TOP w0.127: v1(131.06,58.67) v1(110.74,58.67)
  BOTTOM w0.127: J14.32 110.74,79.38 v1(110.74,58.67) ; v1(131.06,58.67) 131.06,59.18 131.32,59.44 131.32,71.88 131.83,72.39 131.83,73.15 131.44,73.53 131.44,76.83 131.37,76.83 U3.1
SJ4_POT2: length 29.1
  BOTTOM w0.127: 124.69,72.75 124.69,72.64 124.56,72.52 123.57,72.52 123.44,72.39 122.43,72.39 122.17,72.64 122.17,82.68 122.43,82.93 122.43,83.69 122.17,83.95 121.54,83.95 121.28,84.2 114.05,84.2 113.54,83.69 113.54,79.12 J14.85
SJ4_POT3: length 8.7
  TOP w0.127: J14.136 121.67,80.77 122.17,80.26 122.17,76.96 122.68,76.45 v1(124.46,76.45)
  BOTTOM w0.127: 124.51,76.45 v1(124.46,76.45)
SJ4_POT4: length 47.4
  TOP w0.127: v1(105.79,86.74) 129.29,86.74 v1(129.79,86.23)
  BOTTOM w0.127: J14.34 110.24,75.69 110.24,78.61 108.46,80.39 108.46,81.15 110.24,82.93 110.24,83.69 109.73,84.2 106.3,84.2 105.79,84.71 v1(105.79,86.74) ; 129.87,80.37 129.87,81.03 129.79,81.03 v1(129.79,86.23)
SJ4_POT5: length 14.1
  TOP w0.127: J14.87 115.32,74.04 123.06,74.04 123.7,73.41 126.11,73.41 126.24,73.53 126.31,73.53 126.31,73.58 126.44,73.71 v1(126.57,73.71)
  BOTTOM w0.127: U9.12 126.19,73.46 126.44,73.71 v1(126.57,73.71)
SJ4_POT6: length 11.6
  TOP w0.127: v1(124.21,81.28) 124.38,81.1 124.38,77.98 124.51,77.85 124.51,77.37 125.02,76.86 125.02,76.05 124.92,75.95 123.19,75.95 122.94,75.69 J14.138
  BOTTOM w0.127: 124.46,81.03 v1(124.21,81.28)
SJ4_POT11: length 51.8
  TOP w0.127: J14.36 108.46,71.5 106.3,71.5 106.05,71.25 100.97,71.25 100.58,71.63 100.58,72.64 101.09,73.15 105.54,73.15 106.43,72.26 121.28,72.26 122.43,73.41 123.06,73.41 123.32,73.15 128.52,73.15 129.29,73.91 130.18,73.91 130.43,73.66 132.33,73.66 132.59,73.91 132.59,74.68 132.49,74.68 132.23,74.93 132.23,80.01 132.36,80.14 132.36,80.31 v1(132.26,80.42)
  BOTTOM w0.127: U3.12 131.37,80.39 131.39,80.42 v1(132.26,80.42)
SJ4_POT12: length 20.8
  TOP w0.127: v1(121.41,82.04) 124.46,82.04 v1(124.71,82.3)
  BOTTOM w0.127: v1(121.41,82.04) 119.13,82.04 118.62,81.53 118.62,71.5 J14.140 ; v1(124.71,82.3) 124.84,82.17 125.93,82.17 126.03,82.07 U10.12
SJ4_POT13: length 66.8
  TOP w0.127: v1(122.17,63.25) 130.3,63.25 v1(130.56,63.5)
  BOTTOM w0.127: v1(122.17,63.25) 122.17,37.72 121.67,37.21 107.7,37.21 J14.18 105.92,35.43 105.92,21.08 J14.24 ; 130.81,63.75 v1(130.56,63.5)
SJ4_POT14: length 71.3
  BOTTOM w0.127: U9.1 126.19,69.09 126.44,68.83 126.44,65.15 126.31,65.02 126.31,57.53 126.7,57.15 126.7,47.5 127.2,46.99 127.2,46.23 126.95,45.97 126.87,45.97 126.87,38.86 126.49,38.48 126.49,18.16 125.98,17.65 114.05,17.65 111.51,20.19 110.24,20.19 J14.50
SJ4_POT15: length 1.3
  BOTTOM w0.127: 112.78,21.97 J14.76
SJ4_POT16: length 71.5
  TOP w0.127: v1(121.67,43.43) 120.9,43.43 120.4,42.93 120.4,30.86 115.32,25.78 115.32,21.97 J14.102 ; v1(121.41,62.74) v1(129.79,62.74)
  BOTTOM w0.127: v1(121.41,62.74) 121.67,62.48 v1(121.67,43.43) ; v1(129.79,62.74) 129.79,64.9 130.3,65.41 130.3,73.91 129.54,74.68 129.54,75.56 128.91,76.2 126.87,76.2 126.03,77.04 U10.1
SJ4_POTF1: length 8.7
  BOTTOM w0.127: U13.9 142.37,85.96 142.37,85.98 143.38,85.98 144.4,84.96 144.4,84.33 144.93,83.79 145.54,83.79 145.54,83.69 146.56,83.69 146.56,83.67 C60.1 R56.2
SJ4_POTF2: length 8
  BOTTOM w0.127: U13.8 142.37,86.46 142.37,86.49 143.64,86.49 144.53,85.6 144.53,85.55 144.91,85.17 145.54,85.17 145.67,85.04 146.56,85.04 146.56,85.09 C52.1 R45.2
SJ4_POTF3: length 7.6
  BOTTOM w0.127: R37.2 C46.1 146.56,86.49 144.15,86.49 143.89,86.74 143.89,86.79 142.88,86.79 142.75,86.92 142.37,86.92 142.32,86.97 142.32,86.96 U13.7
SJ4_POTF4: length 7.4
  BOTTOM w0.127: R28.2 C35.1 146.56,87.76 146.56,87.78 143.64,87.78 143.36,87.46 U13.6
SJ4_POTF5: length 7.9
  BOTTOM w0.127: R19.2 C25.1 146.43,89.28 144.65,89.28 143.38,88.01 141.6,88.01 141.6,87.96 U13.5
SJ4_POTF6: length 8.3
  BOTTOM w0.127: U13.4 142.24,88.46 142.37,88.59 142.37,88.65 144.4,90.68 146.43,90.68 C24.1 R18.2
SJ4_POTF7: length 9.5
  BOTTOM w0.127: U13.3 142,88.96 142.62,89.59 142.62,91.31 143.26,91.95 146.51,91.95 C13.1 R10.2
SJ4_POTF8: length 10.7
  BOTTOM w0.127: R6.2 C9.1 146.56,93.34 142.9,93.34 142.11,92.51 142.11,89.59 141.99,89.46 141.59,89.46 U13.2
SJ4_POTF9: length 9
  BOTTOM w0.127: R7.2 C10.1 133.6,92.25 135.1,92.25 136.72,90.64 136.72,90.47 136.66,90.42 136.66,89.53 136.69,89.51 136.69,89.49 136.72,89.46 U13.23
SJ4_POTF10: length 8.4
  BOTTOM w0.127: U13.22 136.18,88.96 136.02,89.13 136.02,90.17 135.46,90.73 133.45,90.73 C15.1 R11.2
SJ4_POTF11: length 7.1
  BOTTOM w0.127: R20.2 C26.1 133.48,88.01 135.76,88.01 136.22,88.46 138.09,88.46
SJ4_POTF12: length 7.6
  BOTTOM w0.127: 138.09,87.96 136.35,87.96 136.14,87.76 136.14,87.63 136.12,87.6 135.41,86.94 135.18,86.72 133.25,86.72 132.74,87.22 C36.1 R29.2
SJ4_PRESENTN: length 119.7
  TOP w0.127: J16.46 67.39,136.61 67.69,136.91 84.33,136.91 85.34,137.92 87,137.92 v1(87.25,137.67) ; v1(103.38,85.09) 100.71,85.09 100.2,85.6 100.2,87.38 100.46,87.63 100.46,89.41 99.19,90.68 v1(95.25,90.68) ; v1(103.89,69.09) 104.01,68.96 118.62,68.96 J14.141
  BOTTOM w0.127: v1(95.25,90.68) 95.25,109.98 89.15,116.08 89.15,127.38 90.55,128.78 90.55,135 87.88,137.67 v1(87.25,137.67) ; v1(103.38,85.09) 103.38,69.6 v1(103.89,69.09)
SJ4_REL: length 153.1
  TOP w0.127: v1(114.05,59.18) 121.16,59.18 121.92,59.94 154.94,59.94 155.07,60.07 156.84,60.07 v1(156.97,60.2) ; v1(157.23,111.76) 125.22,111.76 124.97,112.01 115.82,112.01 v1(115.57,112.27)
  BOTTOM w0.127: v1(156.97,60.2) 156.97,61.47 157.48,61.98 157.48,108.59 157.23,108.84 v1(157.23,111.76) ; U27.9 116.71,113.44 116.71,113.49 R76.2 115.52,112.9 115.57,112.9 v1(115.57,112.27) ; J14.62 112.78,69.72 112.78,60.45 v1(114.05,59.18)
SJ4_RELN: length 76.4
  TOP w0.127: J14.65 110.62,64.26 v1(103.12,64.26) ; v1(102.36,85.6) 101.09,85.6 100.46,86.23 100.46,87.12 100.71,87.38 100.71,90.04 v1(100.08,90.68)
  BOTTOM w0.127: v1(102.36,85.6) 102.36,84.58 102.87,84.07 102.87,68.83 103.12,68.58 v1(103.12,64.26) ; v1(100.08,90.68) 99.57,91.19 99.57,125.73 99.69,125.86 R75.2 99.01,126.54 98.93,126.62 98.93,127.51 98.81,127.63 98.76,127.63 U19.2
SJ4_SPARE1: length 220.1
  TOP w0.127: v1(156.72,63.75) 153.29,63.75 153.03,63.5 136.14,63.5 133.35,60.71 129.03,60.71 128.91,60.83 116.97,60.83 v1(116.84,60.71) ; J16.43 64.99,136.36 65.79,137.16 84.2,137.16 85.34,138.3 87.63,138.3 92.58,133.35 94.87,133.35 95.38,132.84 99.57,132.84 99.95,133.22 102.62,133.22 103.38,133.98 110.87,133.98 111.38,133.48 124.33,133.48 130.18,127.63 154.43,127.63 154.56,127.51 155.19,127.51 v1(155.32,127.38)
  BOTTOM w0.127: v1(116.84,60.71) 116.84,51.31 116.33,50.8 114.45,50.8 R85.2 114.45,49.66 114.58,49.66 114.83,49.4 115.14,49.4 C125.1 114.43,48.69 ; v1(155.32,127.38) 155.32,113.66 156.46,112.52 156.46,102.36 156.72,102.11 156.72,100.58 156.46,100.33 156.46,75.95 156.72,75.69 v1(156.72,63.75)
  BOTTOM w0.254: 114.43,48.69 J14.92
SJ4_SPARE2: length 197
  TOP w0.127: v1(122.68,72.9) 130.81,72.9 131.06,72.64 v1(131.32,72.64) 131.57,72.9 136.65,72.9 137.16,73.41 v1(137.16,77.22) ; v1(87.63,140.08) 87.63,139.95 v1(65.41,139.95) ; v1(95.5,111) v1(123.95,111) ; v1(131.83,45.34) 118.11,45.34 J14.118
  BOTTOM w0.127: v1(122.68,72.9) 122.43,73.15 122.43,82.04 124.71,84.33 124.71,110.24 v1(123.95,111) ; J16.44 65.79,134.53 65.79,137.54 65.54,137.79 65.54,139.83 v1(65.41,139.95) ; v1(95.5,111) 95.5,118.87 91.19,123.19 91.19,128.02 90.8,128.4 90.8,135.13 87.63,138.3 v1(87.63,140.08) ; R80.2 137.67,79.04 137.16,78.54 v1(137.16,77.22) ; C126.1 116.97,48.64 ; v1(131.32,72.64) 131.06,72.39 131.06,60.07 130.56,59.56 130.56,58.42 132.46,56.52 132.46,51.94 131.83,51.31 v1(131.83,45.34)
  BOTTOM w0.254: 116.97,48.64 J14.118
VA_BIAS: length 74.8
  TOP w0.127: v1(153.77,52.07) 153.77,50.62 154.03,50.37 ; v1(156.21,50.62) 155.96,50.37 154.03,50.37 ; 154.03,50.37 151.21,50.37 v1(151.13,50.29) ; v1(155.45,82.04) 147.32,82.04 146.69,81.41 139.57,81.41 v1(137.41,83.57) ; v1(153.16,54.97) 156.72,54.97 157.35,55.6 157.35,57.91 157.48,58.04 157.48,58.67 157.18,58.98 155.47,58.98 155.35,58.85 155.32,58.85 154.94,58.47 154.84,58.47 154.69,58.32 v1(154.69,58.19)
  BOTTOM w0.127: v1(153.77,52.07) 153.47,52.37 153.47,53.34 153.34,53.47 153.34,54.86 153.24,54.97 v1(153.16,54.97) ; v1(151.13,50.29) 150.75,49.91 150.72,49.91 R108.2 ; v1(155.45,82.04) 155.45,64.14 155.7,63.88 155.7,59 ; 155.5,58.37 155.5,58.8 155.7,59 ; 155.5,58.37 U23.2 ; 155.5,58.37 154.81,58.37 154.69,58.24 v1(154.69,58.19) ; 155.7,59 U23.1 ; U13.16 136.78,85.96 136.65,85.83 136.65,84.71 137.41,83.95 v1(137.41,83.57) ; R87.2 C130.1 C153.1 v1(156.21,50.62)
VREG: length 23
  TOP w0.254: 154.1,20.5 154.48,20.5 154.79,20.19 154.79,19.05 154.33,18.59 154.33,15.88 154.89,15.32 155.85,15.32 156.67,16.13 R100.2
  TOP w0.381: U26.10 153.53,21.02 154,20.55 154,20.45 C148.2
  TOP w0.508: R112.2 146.15,17.02 147.07,16.1 ; 147.07,16.1 R110.2 ; 147.07,16.1 147.07,15.24 147.57,14.73 154.31,14.73 154.89,15.32 ; C148.2 154.1,20.5
N3819132: length 7.5
  BOTTOM w0.127: U25.3 156.62,51.71 156.72,51.61 156.72,50.22 R95.2 157.61,49.02 R87.1 158.7,47.93 C129.2
N3819136: length 5.3
  BOTTOM w0.127: R96.2 157.56,50.75 R94.1 ; R94.1 C136.1 ; R94.1 157.28,52.35 U25.2
N3819148: length 67.3
  TOP w0.127: v1(152.91,57.15) 152.91,56.64 152.65,56.39 152.65,54.74 153.03,54.36 v1(156.72,54.36) ; v1(134.37,76.96) 134.37,77.72 135.13,78.49 144.27,78.49 144.78,78.99 145.8,78.99 146.3,78.49 150.11,78.49 150.88,77.72 v1(153.92,77.72) ; v1(132.08,84.33) 132.08,84.2 132.72,83.57 134.37,83.57 v1(134.87,83.06)
  BOTTOM w0.127: v1(132.08,84.33) 132.08,84.45 132.16,84.53 R90.1 ; U25.1 156.21,52.98 156.72,53.49 v1(156.72,54.36) 157.07,54 158.62,54 C136.2 R94.2 ; v1(152.91,57.15) 152.91,59.56 152.83,59.56 152.83,60.2 152.7,60.33 152.7,61.14 152.37,61.47 152.27,61.47 152.27,64.64 153.92,66.29 v1(153.92,77.72) ; v1(134.37,76.96) 134.37,77.72 135.38,78.74 135.38,81.41 134.87,81.91 v1(134.87,83.06)
N3819830: length 6.6
  BOTTOM w0.254: C152.1 R109.1 146.89,52.5 147.19,52.2 147.95,52.2 147.95,51.46 148.46,51.46 148.72,51.71 U25.6
N3819870: length 50.2
  TOP w0.127: v1(131.95,58.67) 132.21,58.42 142.24,58.42 144.78,55.88 148.34,55.88 148.84,55.37 v1(148.84,54.99) ; v1(133.35,75.06) 133.35,79.25 133.22,79.38 v1(133.22,80.52)
  BOTTOM w0.127: v1(133.35,75.06) 133.35,74.68 132.08,73.41 132.08,71.88 131.57,71.37 131.57,59.94 131.95,59.56 v1(131.95,58.67) ; v1(148.84,54.99) 148.84,54.58 148.46,54.2 147.95,54.2 147.95,52.83 149.17,52.83 149.61,52.34 U25.7 ; v1(133.22,80.52) 133.22,82.42 132.74,82.91 R113.1
N3819932: length 8
  BOTTOM w0.127: C151.1 150.72,48.26 R108.1 151.79,50.79 151.51,51.07 U25.5 149.5,51.07 147.95,49.53 147.95,49.45 R116.2
N3820466: length 3.7
  TOP w0.254: C148.1 154.15,19.38 153.87,19.38 153.42,19.84 153.42,20.09 152.98,20.52 R118.1
  TOP w0.381: U26.9 152.86,22.18 R118.1
N3821182: length 4.5
  TOP w0.127: U26.16 157.43,21.21 157.99,21.21 159.51,19.68 160.02,19.68 160.1,19.53 R97.1
N3821198: length 5.6
  TOP w0.127: U26.14 156.13,21.19 158.42,18.9 158.6,18.9 R99.1
N3821898: length 1.7
  TOP w0.127: R104.2 151.49,22.11 U26.7
N3920893: length 12.1
  BOTTOM w0.762: L3.1 167.82,116.82 L4.2 172.85,116.82 173.23,117.2 174.24,117.2 174.37,117.07 175.16,117.07 175.41,116.82 ; 175.41,116.82 U24.4 ; 175.41,116.82 175.41,115.32 175.62,115.32 175.87,115.06 C145.1
N4096166: length 3.4
  BOTTOM w0.127: U23.3 157.25,57.73 R88.1 159.03,57.48 R89.2
N5595023: length 0.6
  BOTTOM w0.127: U23.6 U23.7
N6692939: length 56.4
  TOP w0.127: v1(9.14,92.71) 9.14,92.58 12.7,89.03 v1(12.7,85.6) ; v1(10.67,116.08) 10.67,116.71 11.18,117.22 17.53,117.22 18.67,118.36 31.24,118.36 v1(31.5,118.62)
  BOTTOM w0.127: v1(31.5,118.62) 31.5,118.67 R17.1 ; v1(9.14,92.71) 9.14,107.06 10.67,108.59 v1(10.67,116.08) ; 12.7,85.09 v1(12.7,85.6)
N6693001: length 55.9
  TOP w0.127: v1(135.38,84.07) 134.49,84.96 128.02,84.96 127.38,84.33 119,84.33 118.62,84.71 105.79,84.71 104.9,83.82 92.84,83.82 91.31,82.3 v1(91.31,82.17)
  BOTTOM w0.127: v1(135.38,84.07) 136.4,83.06 136.4,81.03 135.89,80.52 135.89,77.98 135.64,77.72 R13.1 ; 91.98,82.33 91.95,82.3 91.44,82.3 v1(91.31,82.17) ; 91.98,82.33 91.98,81.84 U2.5 ; 91.98,82.33 U2.6
N6693049: length 78.7
  TOP w0.127: v1(91.69,84.45) 91.82,84.58 104.9,84.58 105.28,84.96 120.14,84.96 120.9,85.72 130.43,85.72 131.32,86.61 135.89,86.61 136.27,86.23 142.49,86.23 142.62,86.36 149.48,86.36 150.37,85.47 151.89,85.47 152.4,84.96 v1(152.4,84.71)
  BOTTOM w0.127: v1(91.69,84.45) 91.69,84.07 91.95,83.82 91.95,83.36 U2.8 U2.7 ; R38.1 152.78,71.88 152.78,73.66 152.65,73.79 152.15,73.79 151.76,74.17 151.76,80.64 152.4,81.28 v1(152.4,84.71)
N6693089: length 77.3
  TOP w0.127: v1(153.29,84.45) 153.16,84.45 152.91,84.2 152.15,84.2 151.26,85.09 143.76,85.09 143.51,84.84 138.3,84.84 137.67,84.2 136.78,84.2 135.13,82.55 132.84,82.55 131.83,83.57 122.05,83.57 v1(121.92,83.44) ; v1(121.67,79.76) 110.87,79.76 110.74,79.88 106.17,79.88 104.39,81.66 101.6,81.66 101.09,82.17 96.77,82.17 96.27,81.66 95.76,81.66 95.5,81.91 95.5,82.42 96.01,82.93 v1(96.01,83.06)
  BOTTOM w0.127: v1(153.29,84.45) 152.91,84.07 152.91,76.71 R12.1 ; U2.13 95.74,83.33 v1(96.01,83.06) 96.01,82.85 95.99,82.83 U2.14 ; v1(121.67,79.76) 121.92,80.01 v1(121.92,83.44)
N6693129: length 46.3
  TOP w0.127: v1(132.84,72.39) 132.59,72.14 130.43,72.14 130.05,72.52 123.7,72.52 123.19,72.01 104.27,72.01 v1(103.89,72.39) ; v1(100.58,78.23) v1(103.89,78.23)
  BOTTOM w0.127: v1(103.89,78.23) v1(103.89,72.39) ; v1(132.84,72.39) 134.37,73.91 134.37,74.27 134.87,74.78 R22.1 ; 100.34,78.48 100.7,78.48 100.58,78.36 v1(100.58,78.23) 100.34,78.48 ; 100.34,78.48 U5.16 ; 100.34,78.48 100.22,78.6 100.22,78.72 99.97,78.98 U5.15
N6693173: length 75.8
  TOP w0.127: v1(93.98,62.23) 93.98,60.96 94.49,60.45 111,60.45 111.76,61.21 v1(129.29,61.21) ; v1(129.79,73.41) v1(134.62,73.41)
  BOTTOM w0.127: v1(93.98,62.23) 93.98,71.88 94.49,72.39 94.49,77.97 94.74,78.22 ; v1(134.62,73.41) R31.1 ; U5.6 95.76,78.98 95.63,78.85 94.49,78.85 94.49,78.48 94.74,78.22 ; U5.5 95,78.48 94.74,78.22 ; v1(129.79,73.41) 129.79,65.41 129.29,64.9 v1(129.29,61.21)
N6693213: length 62.5
  TOP w0.127: v1(44.96,114.55) 44.96,112.52 45.47,112.01 51.56,112.01 53.59,109.98 v1(70.36,109.98)
  BOTTOM w0.127: U8.15 68.96,79.28 ; 68.96,79.28 70.14,79.28 70.36,79.5 v1(70.36,109.98) ; 68.96,79.28 68.96,78.91 68.83,78.78 U8.16 ; R41.1 45.47,114.71 45.47,114.68 45.34,114.55 v1(44.96,114.55)
N6693217: length 45.2
  TOP w0.127: v1(68.33,120.27) 67.94,120.27 66.93,121.28 v1(65.38,121.28)
  BOTTOM w0.127: U8.14 U8.13 68.72,82.41 68.33,82.81 v1(68.33,120.27) ; R59.1 65.25,121.41 65.38,121.54 v1(65.38,121.28)
N6693221: length 75
  TOP w0.127: v1(95.38,80.14) 95.38,78.49 95.88,77.98 99.44,77.98 99.69,77.72 v1(101.6,77.72) ; v1(152.91,66.55) 152.65,66.29 143,66.29 142.88,66.42 139.06,66.42 138.18,65.53 137.16,65.53 136.65,66.04 130.81,66.04 127.76,69.09 119.13,69.09 119,69.22 104.52,69.22 104.14,69.6 v1(101.6,69.6)
  BOTTOM w0.127: R46.1 152.91,68.45 v1(152.91,66.55) ; U5.8 95.63,79.97 95.5,80.1 95.41,80.1 ; 95.41,80.1 v1(95.38,80.14) ; 95.41,80.1 95.5,80.01 95.5,79.6 95.63,79.48 U5.7 ; v1(101.6,69.6) v1(101.6,77.72)
N6693293: length 74.2
  TOP w0.127: v1(121.67,67.82) 125.86,67.82 128.4,65.28 133.1,65.28 133.35,65.53 136.02,65.53 136.53,65.02 138.94,65.02 139.19,65.28 v1(144.53,65.28) ; v1(100.46,79.38) 110.74,79.38 110.87,79.25 120.9,79.25 v1(121.16,78.99)
  BOTTOM w0.127: v1(121.16,78.99) 121.16,68.33 v1(121.67,67.82) ; 99.86,79.97 99.95,79.97 99.95,79.88 ; 99.86,79.97 99.95,79.88 ; 99.86,79.97 U5.13 ; U5.14 100.05,79.48 100.2,79.63 ; 99.95,79.88 100.2,79.63 ; R30.1 151.76,72.77 151.76,66.29 150.75,65.28 v1(144.53,65.28) ; 100.2,79.63 v1(100.46,79.38)
N6693311: length 76
  TOP w0.127: v1(122.94,81.03) 121.67,81.03 120.4,82.3 115.44,82.3 115.32,82.42 96.27,82.42 v1(96.01,82.17) ; v1(152.15,65.79) 139.32,65.79 138.81,65.28 136.91,65.28 136.4,65.79 v1(129.29,65.79)
  BOTTOM w0.127: 95.25,82.33 95.63,82.33 95.63,82.3 95.88,82.3 v1(96.01,82.17) ; 95.25,82.33 U2.15 ; 95.25,82.33 95.25,81.93 95.15,81.83 U2.16 ; v1(152.15,65.79) 152.15,67.18 152.25,67.18 R58.1 ; v1(122.94,81.03) 122.68,80.77 122.68,76.45 123.19,75.95 128.27,75.95 129.29,74.93 v1(129.29,65.79)
N6693321: length 41.2
  TOP w0.127: v1(31.39,117.17) 31.33,117.23 31.01,116.92 30.99,116.92 30.61,116.54 23.37,116.54 23.24,116.41 23.24,116.33 22.99,116.08 v1(14.48,116.08) ; v1(19.81,109.85) 19.43,110.24 14.99,110.24 14.48,110.74 v1(14.48,111.25)
  BOTTOM w0.127: 19.41,101.25 19.4,101.24 19,101.24 18.9,101.35 18.9,107.06 19.28,107.44 19.3,107.44 19.81,107.95 v1(19.81,109.85) ; 19.41,101.25 U1.7 ; 19.41,101.25 19.9,100.75 U1.8 ; v1(31.39,117.17) 31.27,117.3 R25.1 ; v1(14.48,111.25) v1(14.48,116.08)
N6693393: length 40.2
  TOP w0.127: v1(132.84,71.12) 129.29,71.12 128.91,71.5 127.13,71.5 126.37,72.26 124.33,72.26 123.83,71.75 101.22,71.75 v1(101.09,71.88)
  BOTTOM w0.127: U7.15 99.69,71.81 99.69,71.75 100.58,71.75 100.71,71.88 101.04,71.88 ; 101.04,71.88 100.47,71.31 U7.16 ; 101.04,71.88 v1(101.09,71.88) ; R48.1 133.48,72.03 132.97,71.53 132.97,71.25 v1(132.84,71.12)
N6693431: length 68.8
  TOP w0.127: v1(95.07,70.82) 94.95,70.82 95.33,70.43 101.6,70.43 102.11,70.94 103.89,70.94 104.14,70.69 104.83,70.69 105.79,69.72 120.78,69.72 121.54,70.48 124.08,70.48 124.46,70.1 126.62,70.1 126.87,70.36 132.84,70.36 133.35,70.87 133.35,71.17 133.73,71.55 135.51,71.55 135.64,71.42 140.46,71.42 140.69,71.2 140.69,68.91 141.63,67.97 145.82,67.97 147.75,69.9 152.93,69.9 153.06,70.03 153.16,70.03 ; 153.16,70.03 153.16,70 153.19,70.03 153.16,70.03 ; 153.16,70.03 v1(153.16,70.51)
  BOTTOM w0.127: v1(153.16,70.51) R39.1 ; 94.97,71.33 94.97,71.32 94.97,70.84 94.95,70.82 v1(95.07,70.82) ; 94.97,71.33 95.38,71.73 95.38,71.81 U7.6 ; 94.97,71.33 94.99,71.31 U7.5
N6693465: length 75.8
  TOP w0.127: v1(94.49,70.1) 104.9,70.1 105.54,69.47 121.03,69.47 121.79,70.23 123.95,70.23 124.33,69.85 126.75,69.85 127,70.1 133.22,70.1 134.37,71.25 135.18,71.25 135.25,71.17 140.31,71.17 140.44,71.04 140.44,68.63 141.38,67.69 146.43,67.69 147.32,68.58 151.26,68.58 152.32,69.65 153.29,69.65 153.67,70.03 153.67,74.22 153.54,74.35 153.42,74.35 153.16,74.09 v1(153.16,74.22)
  BOTTOM w0.127: 95.12,72.31 95.12,72.01 94.49,71.37 v1(94.49,70.1) ; 95.12,72.31 95.12,72.36 ; 95.12,72.31 95.13,72.31 ; 95.12,72.36 95.38,72.62 ; 95.12,72.36 95.1,72.34 95.13,72.31 ; 95.13,72.31 U7.7 ; 95.57,72.81 U7.8 96.16,72.81 96.16,72.82 96.15,72.81 ; 95.57,72.81 95.5,72.81 95.38,72.68 95.38,72.62 ; 95.57,72.81 95.38,72.62 ; R21.1 152.78,74.63 152.78,74.5 153.16,74.12 v1(153.16,74.22)
N6693509: length 67.4
  TOP w0.127: v1(152.4,80.52) 151.89,80.52 151.26,81.15 148.72,81.15 147.57,80.01 134.62,80.01 133.6,81.03 132.08,81.03 131.7,80.64 131.7,75.06 131.19,74.55 130.68,74.55 130.56,74.68 126.87,74.68 126.37,74.17 126.24,74.17 126.11,74.04 123.7,74.04 123.44,74.3 v1(100.2,74.3)
  BOTTOM w0.127: U7.14 99.95,72.31 100.08,72.44 100.08,72.68 99.69,72.68 ; v1(152.4,80.52) 152.15,80.26 152.15,77.98 152.25,77.98 R8.1 ; v1(100.2,74.3) 99.69,73.79 99.69,72.68 ; U7.13 99.65,72.81 99.65,72.68 99.69,72.68
N6693557: length 50
  TOP w0.127: v1(15.39,118.59) 15.39,118.49 9.68,118.49 9.4,118.21 v1(9.22,118.21) ; v1(8.64,83.57) 8.64,90.3 9.02,90.68 v1(9.02,90.93)
  BOTTOM w0.127: v1(8.64,83.57) 8.64,79.5 9.02,79.12 9.61,79.12 U6.6 U6.5 ; v1(9.22,118.21) 9.32,118.21 8.81,117.7 8.81,111.79 8.48,111.46 8.48,110.79 9.07,110.21 9.07,108.51 7.62,107.06 7.62,94.11 8.13,93.6 8.13,92.58 9.02,91.69 v1(9.02,90.93) ; v1(15.39,118.59) 15.39,118.16 15.49,118.06 R27.1
N6693601: length 59.7
  TOP w0.127: v1(35.05,79.38) 31.75,79.38 31.24,79.88 31.24,92.84 29.59,94.49 25.65,94.49 24.77,95.38 24.77,97.66 24.38,98.04 v1(24.38,99.44)
  BOTTOM w0.127: R26.1 16.64,116.21 16.64,109.73 16.89,109.47 17.91,109.47 18.8,110.36 20.07,110.36 20.32,110.11 20.32,108.2 20.83,107.7 23.88,107.7 24.38,107.19 v1(24.38,99.44) ; U12.16 37.45,75.82 37.42,75.79 36.97,75.79 36.95,75.82 U12.15 36.95,76.71 36.7,76.96 35.81,76.96 35.05,77.72 v1(35.05,79.38)
N6693683: length 46.7
  TOP w0.127: v1(33.02,108.84) 32.51,108.33 29.21,108.33 29.08,108.2 27.81,108.2 27.18,107.57 20.19,107.57 18.8,106.17 18.8,105.16 14.99,101.35 11.18,101.35 v1(10.41,100.58)
  BOTTOM w0.127: v1(33.02,108.84) 32.89,108.97 32.89,114.05 32.38,114.55 R35.1 ; U6.7 U6.8 9.62,80.14 ; 10.41,88.9 v1(10.41,100.58)
N6693747: length 63.5
  TOP w0.127: v1(13.72,80.14) 13.72,92.71 12.95,93.47 8,93.47 7.75,93.22 v1(7.11,93.22) ; v1(8.51,109.09) 9.14,109.09 12.06,112.01 16.26,112.01 17.53,110.74 23.37,110.74 23.88,110.24 24.77,110.24 25.76,111.23 26.67,111.23 26.8,111.1 31.29,111.1 31.39,111 31.39,110.95 v1(31.14,110.95)
  BOTTOM w0.127: 13.84,80.01 v1(13.72,80.14) ; R60.1 31.01,110.44 31.14,110.57 v1(31.14,110.95) ; v1(7.11,93.22) 7.11,108.59 7.62,109.09 v1(8.51,109.09)
N6693757: length 17.5
  TOP w0.127: v1(127.89,87.38) 128.14,87.63 v1(129.03,87.63)
  BOTTOM w0.127: v1(129.03,87.63) 128.91,87.63 128.78,87.5 128.78,80.77 128.52,80.52 128.52,78.67 U3.6 U3.5 ; R7.1 130.3,90.8 130.18,90.68 128.65,90.68 128.14,90.17 128.14,87.63 v1(127.89,87.38)
N6693797: length 28.6
  TOP w0.127: v1(147.7,81.15) 147.7,80.77 147.19,80.26 135.13,80.26 134.11,81.28 130.05,81.28 v1(129.29,80.52)
  BOTTOM w0.127: R28.1 148.97,86.49 149.1,86.36 149.1,82.68 147.7,81.28 v1(147.7,81.15) ; U3.7 128.96,79.17 128.85,79.27 128.85,79.57 128.96,79.67 ; 128.96,79.67 U3.8 ; 128.96,79.67 129.03,79.75 129.03,80.26 v1(129.29,80.52)
N6693837: length 33.6
  TOP w0.127: v1(150.7,80.54) 150.6,80.44 149.86,80.44 149.68,80.26 148.21,80.26 147.7,79.76 133.93,79.76 v1(133.83,79.65)
  BOTTOM w0.127: U3.14 133.17,79.17 133.2,79.2 133.38,79.2 v1(133.83,79.65) 133.82,79.67 U3.13 ; v1(150.7,80.54) 150.83,80.67 150.83,83.06 150.95,83.19 150.95,83.82 151.08,83.95 151.08,87.5 150.57,88.01 149.28,88.01 149.17,88.11 149.12,88.11 149.1,88.14 149.1,90.68 R10.1
N6693887: length 46.4
  BOTTOM w0.127: 127.63,70.81 127.63,71.05 U9.15 ; 127.63,70.81 127.7,70.81 128.52,69.98 128.52,61.21 129.03,60.71 130.05,60.71 130.56,61.21 130.56,62.74 130.05,63.25 130.05,64.01 130.56,64.52 130.56,74.04 130.05,74.55 130.05,75.82 128.4,77.47 128.4,78.36 128.27,78.49 128.27,80.9 128.4,81.03 128.4,88.77 128.91,89.28 130.05,89.28 130.3,89.53 R11.1 ; 127.63,70.81 127.89,70.55 U9.16
N6693927: length 40.1
  TOP w0.127: v1(132.33,69.6) 132.08,69.85 127.51,69.85 127.25,69.6 v1(123.7,69.6) ; v1(129.29,83.06) 129.29,82.3 129.79,81.79 136.4,81.79 136.91,81.28 v1(136.91,80.77)
  BOTTOM w0.127: v1(136.91,80.77) 136.14,80.01 136.14,71.63 136.02,71.5 134.24,71.5 v1(132.33,69.6) ; 123.95,70.55 U9.5 ; 123.95,70.55 123.7,70.3 v1(123.7,69.6) ; 123.95,70.55 123.95,71.05 U9.6 ; R20.1 129.92,88.65 129.67,88.39 129.67,87.25 129.29,86.87 v1(129.29,83.06)
N6693931: length 44.5
  TOP w0.127: v1(32.26,116.84) 34.8,116.84 v1(35.05,116.59) ; v1(19.81,96.39) 19.81,96.52 20.32,97.03 20.32,100.84 20.7,101.22 v1(35.05,101.22)
  BOTTOM w0.127: U1.14 19.41,96.67 19.69,96.39 v1(19.81,96.39) 19.9,96.43 U1.13 ; v1(32.26,116.84) 32.26,118.87 31.75,119.38 30.61,119.38 30.48,119.51 R9.1 ; v1(35.05,116.59) v1(35.05,101.22)
N6693983: length 42.1
  TOP w0.127: v1(122.94,71.12) 123.83,71.12 124.59,70.36 126.49,70.36 126.75,70.61 128.14,70.61 v1(128.52,70.99) ; v1(149.99,79.76) 148.08,79.76 147.83,79.5 135.13,79.5 v1(134.87,79.25) ; v1(132.08,74.17) v1(128.52,74.17)
  BOTTOM w0.127: v1(134.87,79.25) 134.62,78.99 134.62,78.49 133.6,77.47 133.6,76.07 132.08,74.55 v1(132.08,74.17) ; 123.56,71.55 123.32,71.55 123.32,71.37 123.06,71.12 v1(122.94,71.12) ; 123.56,71.55 U9.7 ; 123.56,71.55 123.51,71.6 123.56,71.65 123.56,71.95 123.66,72.05 U9.8 ; R45.1 150.37,83.69 150.37,82.55 150.39,82.55 150.52,82.42 150.52,81.64 150.01,81.13 150.14,81.13 150.14,80.75 149.99,80.59 v1(149.99,79.76) ; v1(128.52,74.17) v1(128.52,70.99)
N6694061: length 43.8
  TOP w0.127: v1(145.29,78.49) 145.03,78.23 138.43,78.23 137.92,77.72 137.92,72.39 137.41,71.88 132.46,71.88 131.95,71.37 129.79,71.37 129.16,72.01 v1(128.02,72.01)
  BOTTOM w0.127: v1(128.02,72.01) 127.89,72.01 127.63,71.75 ; 127.3,71.55 127.63,71.88 ; 127.3,71.55 U9.14 ; 127.3,71.55 127.51,71.55 127.63,71.68 127.63,71.75 ; 127.63,71.88 127.63,71.75 ; 127.63,71.88 127.76,72.01 127.63,72.01 127.63,72.05 U9.13 ; v1(145.29,78.49) 145.54,78.74 150.88,78.74 151.38,79.25 151.38,87.88 150.88,88.39 150.5,88.39 150.37,88.52 150.37,88.62 150.24,88.49 R19.1
N6694105: length 23.5
  TOP w0.127: v1(149.1,79.25) 143,79.25 142.49,78.74 v1(134.11,78.74)
  BOTTOM w0.127: R56.1 149.66,82.42 149.61,82.42 149.61,82.3 149.1,81.79 v1(149.1,79.25) ; U3.15 133.91,78.67 133.96,78.72 133.96,78.74 v1(134.11,78.74) 133.54,78.17 U3.16
N6694159: length 26.5
  TOP w0.127: v1(127.89,78.11) 127.76,78.11 127.51,77.85 127.51,77.83 127.46,77.83 127.36,77.93 127.48,77.93 127.48,81.41 127,81.89 127,82.3 126.49,82.8 121.79,82.8 121.41,83.19 121.41,83.69 121.67,83.95 129.92,83.95 v1(130.3,84.33)
  BOTTOM w0.127: U10.15 127.32,78.67 v1(127.89,78.11) 127.51,78.11 127.51,78.17 U10.16 ; v1(130.3,84.33) R29.1
N6694205: length 39.4
  TOP w0.127: v1(150.57,86.26) 150.57,86.28 149.1,87.76 141.33,87.76 140.69,88.39 v1(125.48,88.39)
  BOTTOM w0.127: v1(150.57,86.26) 150.57,86.13 150.5,86.13 150.24,85.88 150.24,85.75 R37.1 ; v1(125.48,88.39) 125.48,84.56 123.44,82.59 123.44,80.62 122.98,80.2 122.98,78.67 U10.6 U10.5
N6694213: length 74.6
  TOP w0.127: v1(32.77,80.26) 34.29,80.26 34.54,80.52 34.54,82.04 34.29,82.3 34.29,91.44 v1(36.2,93.34) ; v1(36.32,115.57) 34.54,115.57 33.91,116.21 25.4,116.21 24.51,115.32 v1(15.24,115.32)
  BOTTOM w0.127: v1(36.2,93.34) 36.32,93.47 v1(36.32,115.57) ; v1(32.77,80.26) 32.77,72.14 33.27,71.63 36.58,71.63 36.7,71.75 36.76,71.82 36.77,71.82 36.95,72 U12.6 U12.5 ; v1(15.24,115.32) R36.1
N6694291: length 38.8
  TOP w0.127: v1(150.57,89.87) 150.55,89.84 148.77,89.84 148.34,89.41 142.37,89.41 141.94,89.84 137.74,89.84 136.91,90.68 v1(125.98,90.68)
  BOTTOM w0.127: U10.7 U10.8 123.7,79.67 123.7,82.42 125.86,84.58 125.86,87.12 125.98,87.25 v1(125.98,90.68) ; v1(150.57,89.87) R18.1
N6694359: length 40.6
  TOP w0.127: v1(150.57,92.35) 150.83,92.61 150.98,92.61 151.08,92.51 151.08,89.46 150.9,89.28 150.88,89.28 149.73,88.14 141.6,88.14 140.34,89.41 127.51,89.41 v1(127.13,89.03)
  BOTTOM w0.127: U10.14 126.77,79.17 126.75,79.2 126.75,79.54 126.87,79.67 ; R6.1 150.32,92.61 v1(150.57,92.35) ; v1(127.13,89.03) 126.24,88.14 126.24,82.8 126.87,82.17 126.87,79.67 ; 126.87,79.67 U10.13
N6694505: length 55.8
  TOP w0.127: v1(45.34,119.51) 45.21,119.63 v1(34.29,119.63) ; v1(33.91,93.73) 33.27,93.73 32.77,93.22 32.77,81.28 33.27,80.77 v1(34.04,80.77)
  BOTTOM w0.127: v1(33.91,93.73) 34.04,93.85 34.04,100.2 34.29,100.46 v1(34.29,119.63) ; R16.1 v1(45.34,119.51) ; 34.14,80.76 34.05,80.76 v1(34.04,80.77) ; 34.14,80.76 34.04,80.86 34.04,81.01 34.29,81.26 U4.6 ; 34.14,80.76 U4.5
N6694569: length 63.3
  TOP w0.127: v1(65.84,112.42) 65.66,112.24 64.24,112.24 63.25,111.25 57.66,111.25 v1(57.15,111.76) ; v1(56.13,101.6) 56.13,101.09 54.48,99.44 43.05,99.44 42.42,98.81 42.42,93.85 40.77,92.2 40.13,92.2 39.62,92.71 37.46,92.71 36.83,92.08 36.83,85.09 36.32,84.58 35.81,84.58 v1(34.8,83.57)
  BOTTOM w0.127: R32.1 65.02,116.08 65.15,115.95 65.15,115.19 65.63,114.71 65.63,112.5 65.71,112.42 v1(65.84,112.42) ; v1(56.13,101.6) 56.13,104.39 56.39,104.65 56.39,108.2 57.15,108.97 v1(57.15,111.76) ; v1(34.8,83.57) 34.71,83.46 34.71,83.4 35.31,82.8 35.31,82.35 35.21,82.26 U4.8 U4.7
N6694609: length 84.1
  TOP w0.127: v1(33.15,119.89) 33.4,120.14 55.63,120.14 56.01,120.52 65.02,120.52 65.15,120.65 v1(66.04,120.65)
  BOTTOM w0.127: 64.64,119.86 64.64,119.94 64.69,119.94 64.69,119.81 64.64,119.86 ; 64.64,119.86 R14.1 ; 64.64,119.86 64.64,119.81 64.57,119.81 64.82,119.56 64.95,119.56 64.95,119.62 64.9,119.62 64.9,119.68 65.02,119.56 65.51,119.56 66.4,120.45 66.4,120.57 66.29,120.52 66.17,120.65 v1(66.04,120.65) ; 38.86,82.26 39.24,82.64 39.24,84.43 37.19,86.49 32.05,86.49 31.72,86.82 31.72,93.34 31.5,93.57 31.5,99.06 33.78,101.35 33.78,109.09 33.15,109.73 v1(33.15,119.89) ; 38.86,82.26 38.99,82.13 38.99,81.89 38.86,81.76 U4.14 ; 38.86,82.26 U4.13
N6694661: length 75.9
  TOP w0.127: v1(57.15,120.01) 57.15,119.99 56.92,119.76 49.1,119.76 48.97,119.63 48.97,117.53 48.89,117.45 v1(45.24,117.45) ; v1(66.17,82.55) 66.04,82.42 66.04,78.49 67.06,77.47 v1(67.06,74.42)
  BOTTOM w0.127: U11.16 67.47,73.52 67.28,73.71 66.97,73.71 ; R24.1 v1(45.24,117.45) ; 66.97,73.71 U11.15 ; 66.97,73.71 66.97,74.04 67.06,74.04 v1(67.06,74.42) ; v1(57.15,120.01) 57.15,121.41 57.66,121.92 65.66,121.92 67.06,120.52 67.06,84.07 66.17,83.19 v1(66.17,82.55)
N6694723: length 81.4
  TOP w0.127: v1(45.24,116.33) 45.11,116.21 45.11,116.08 45.62,116.59 48.89,116.59 49.4,117.09 49.4,118.87 49.91,119.38 56.39,119.38 57.53,118.24 65.02,118.24 65.15,118.36 v1(65.53,118.36) ; v1(68.2,70.48) 68.33,70.61 68.33,73.41 69.47,74.55 69.47,77.85 68.83,78.49 68.83,83.06 68.07,83.82 63.75,83.82 v1(63.5,84.07)
  BOTTOM w0.127: v1(63.5,84.07) 63.63,84.2 63.63,98.04 63.5,98.17 63.5,98.81 63.75,99.06 63.75,107.95 64.26,108.46 64.26,109.47 63.88,109.85 63.88,117.73 64.13,117.98 64.64,117.98 65.02,118.36 v1(65.53,118.36) ; 67.47,70.48 67.43,70.44 U11.6 ; 67.47,70.48 v1(68.2,70.48) ; 67.47,70.48 U11.5 ; R33.1 45.24,116.08 45.11,116.21 v1(45.24,116.33)
N6694749: length 49.8
  TOP w0.127: v1(63.5,74.68) 61.98,76.2 61.98,79.88 61.59,80.26 v1(60.83,80.26)
  BOTTOM w0.127: v1(60.83,80.26) 61.21,80.64 61.21,81.79 61.72,82.3 62.48,82.3 64.52,84.33 64.52,107.7 65.02,108.2 65.02,112.78 R49.1 ; 66.47,70.44 U11.7 U11.8 63.93,70.44 63.25,71.12 63.25,74.42 v1(63.5,74.68)
N6694819: length 50.1
  TOP w0.127: v1(65.02,82.8) 64.77,82.55 64.77,82.04 64.52,81.79 64.01,81.79 63.5,81.28 v1(63.5,81.03) ; v1(63.5,76.33) 65.28,76.33 v1(65.53,76.07)
  BOTTOM w0.127: v1(65.02,82.8) 65.02,97.03 65.79,97.79 65.79,109.73 66.42,110.36 66.42,112.9 65.91,113.41 65.91,116.33 65.41,116.84 64.59,116.84 64.47,116.97 R23.1 ; 65.97,74 66.01,74.04 66.42,74.04 66.47,73.99 66.47,73.39 ; 65.97,74 U11.13 ; 65.97,74 65.97,74.04 65.91,74.04 65.53,74.42 v1(65.53,76.07) ; v1(63.5,76.33) v1(63.5,81.03)
N6694859: length 55.2
  TOP w0.127: v1(39.37,91.82) 40.89,91.82 43.18,94.11 43.18,95.88 45.85,98.55 v1(64.01,98.55)
  BOTTOM w0.127: v1(64.01,98.55) 64.01,107.7 64.77,108.46 64.77,109.73 64.47,110.03 R50.1 ; 38.86,81.28 38.86,80.76 U4.16 ; 38.86,81.28 38.73,81.28 38.72,81.26 U4.15 ; 38.86,81.28 39.12,81.28 39.62,81.79 39.62,87.12 39.37,87.38 v1(39.37,91.82)
N6695135: length 50
  TOP w0.127: v1(62.23,81.41) 63.12,82.3 v1(64.26,82.3)
  BOTTOM w0.127: 65.02,78.78 65.02,76.83 64.01,75.82 61.21,75.82 60.96,76.07 60.96,78.11 61.85,78.99 61.85,81.03 v1(62.23,81.41) ; 65.02,78.78 U8.5 ; 65.02,78.78 65.02,79.28 U8.6 ; R40.1 65.15,114.05 65.28,113.92 65.28,107.95 64.77,107.44 64.77,83.31 64.26,82.8 v1(64.26,82.3)
N6695209: length 48.4
  TOP w0.127: v1(66.04,84.33) 64.01,84.33 63.75,84.58 63.25,84.58 62.99,84.33 62.99,83.82 63.5,83.31 65.28,83.31 65.53,83.06 65.53,82.3 65.02,81.79 v1(65.02,81.03)
  BOTTOM w0.127: 65.02,80.28 v1(65.02,81.03) ; 65.02,80.28 U8.8 ; 65.02,80.28 65.02,79.78 U8.7 ; R15.1 64.82,118.67 65.15,119 65.79,119 66.27,118.52 66.27,113.56 66.67,113.16 66.67,110.24 66.04,109.6 v1(66.04,84.33)
N6695471: length 64.6
  TOP w0.127: v1(33.53,85.6) 34.04,86.11 34.04,91.57 34.54,92.08 v1(34.54,92.96)
  BOTTOM w0.127: v1(33.53,85.6) 33.27,85.34 33.27,73.66 33.78,73.15 35.7,73.15 35.95,72.9 U12.8 36.45,72.88 ; v1(34.54,92.96) 34.54,116.84 34.8,117.09 34.8,120.14 34.29,120.65 30.23,120.65 29.97,120.4 29.97,112.65 29.85,112.52 R54.1
N6695607: length 54.6
  TOP w0.127: v1(33.27,92.84) 33.27,88.14 33.02,87.88 33.02,83.57 33.53,83.06 v1(33.78,83.06)
  BOTTOM w0.127: v1(33.78,83.06) 33.53,82.8 33.53,78.49 35.95,76.06 U12.13 36.45,75.83 ; v1(33.27,92.84) 33.27,100.33 34.04,101.09 34.04,112.27 33.66,112.65 33.66,120.14 33.4,120.4 32.89,120.4 32.51,120.01 32.51,119.25 32.77,119 32.77,116.33 32.36,115.93 R34.1
N6695787: length 35.3
  BOTTOM w0.127: U1.15 18.91,96.63 18.8,96.52 18.42,96.52 18.42,97.26 U1.16 18.4,97.16 18.15,96.9 16,96.9 15.49,97.41 15.49,101.22 17.02,102.74 17.02,107.95 16.51,108.46 14.1,108.46 12.95,109.6 12.89,109.6 12.89,112.01 12.83,112.01 12.83,113.54 12.95,113.66 13.72,113.66 13.97,113.41 13.97,110.74 14.48,110.24 14.6,110.24 14.99,110.62 14.99,112.01 14.86,112.14 14.86,113.92 14.88,113.94 R43.1
N6695799: length 26.9
  TOP w0.127: v1(18.8,107.95) 20.83,107.95 21.84,108.97 22.35,108.97 22.61,108.71 28.45,108.71 28.7,108.97 31.11,108.97 v1(31.37,109.22)
  BOTTOM w0.127: U1.5 18.4,100.31 18.61,100.52 18.91,100.52 ; 18.91,100.52 18.91,100.97 18.9,100.97 18.64,101.22 18.64,107.82 18.77,107.95 v1(18.8,107.95) ; 18.91,100.52 U1.6 ; v1(31.37,109.22) 31.75,109.6 31.75,112.01 31.24,112.52 30.61,112.52 30.48,112.65 R42.1
N7118838: length 17.6
  TOP w0.508: v1(173.99,116.33) 173.99,117.35 174.5,117.86 178.31,117.86 178.82,118.36 v1(178.82,118.87)
  BOTTOM w0.508: 172.33,113.72 173.61,115 173.61,114.94 173.99,115.32 v1(173.99,116.33) ; 172.33,113.72 L4.1 ; 172.33,113.72 D3.3 ; v1(178.82,118.87) 178.82,121.28 179.07,121.54 179.1,121.54 179.1,121.67 179.22,121.79 U24.8
N7211399: length 22.5
  TOP w0.127: v1(106.68,114.81) 106.93,115.06 122.05,115.06 v1(122.43,114.68)
  BOTTOM w0.127: v1(122.43,114.68) 122.43,114.74 U27.4 ; U20.3 106.79,118.73 106.68,118.62 v1(106.68,114.81)
N7227895: length 43.5
  TOP w0.127: v1(127.76,123.95) 114.05,123.95 112.52,125.48 111.51,125.48 111.25,125.73 106.55,125.73 106.05,126.24 105.03,126.24 v1(104.77,126.49)
  BOTTOM w0.127: U27.6 124.59,113.44 124.68,113.54 125.6,113.54 126.24,112.9 127.13,112.9 127.76,113.54 v1(127.76,123.95) ; v1(104.77,126.49) 104.77,126.11 104.65,125.98 104.65,125.09 105.16,124.59 105.16,123.19 105.28,123.06 105.29,123.06 U20.9
N7242621: length 20.2
  TOP w0.127: v1(108.58,119.38) 121.92,119.38 v1(122.43,118.87)
  BOTTOM w0.127: U20.1 108.46,120.89 108.58,120.76 v1(108.58,119.38) ; U27.2 122.84,116.04 122.43,116.45 v1(122.43,118.87)
N7330649: length 40.7
  TOP w0.127: v1(115.57,127) 107.19,127 106.68,127.51 103.76,127.51 103.5,127.25 100.2,127.25 v1(99.95,127)
  BOTTOM w0.127: v1(115.57,127) 119.89,127 120.4,126.49 120.4,113.03 120.16,112.79 U27.8 ; U19.1 100.21,129.42 100.2,129.41 100.2,127.25 v1(99.95,127)
N7684770: length 19.7
  TOP w0.203: v1(98.25,127.51) 98.42,127.51 98.42,127.48 98.6,127.66 98.98,127.66 99.24,127.91 104.22,127.91 104.52,128.22 107.06,128.22 107.31,127.97 110.03,127.97 111.12,129.06 112.27,129.06 112.65,129.44 114.1,129.44 114.15,129.49 v1(114.15,129.24)
  BOTTOM w0.203: v1(114.15,129.24) 114.15,129.49 114.15,129.49 U18.12 ; U19.3 v1(98.25,127.51)
N7703211: length 48.2
  TOP w0.127: v1(108.97,130.3) 107.82,131.44 99.44,131.44 98.81,130.81 97.79,130.81 96.77,131.83 v1(96.65,131.7)
  BOTTOM w0.127: v1(108.97,130.3) 109.98,129.29 109.98,109.6 110.49,109.09 114.43,109.09 114.94,109.6 114.94,113.92 115.11,114.09 U27.10 ; v1(96.65,131.7) 96.63,131.7 96.76,131.57 U19.9
N7735582: length 7.2
  BOTTOM w0.127: R67.2 C53.1 R57.1 13.46,110.11 13.46,109.47 13.72,109.22 15.75,109.22 16,109.47 16.15,109.47 R123.1
N7735586: length 4.1
  BOTTOM w0.127: R122.1 C55.1 R47.1 R66.2
N7735590: length 4.8
  BOTTOM w0.127: R65.2 136.78,68.83 136.53,68.58 136.27,68.58 R121.1 C58.1 R51.1
N7735594: length 30.3
  TOP w0.127: v1(130.81,82.55) 131.32,82.04 137.92,82.04 138.43,81.53 v1(138.68,81.53)
  BOTTOM w0.127: R61.1 C65.1 129.84,100.61 129.82,100.61 128.78,99.57 R64.2 128.78,96.27 130.81,94.23 v1(130.81,82.55) ; R120.1 v1(138.68,81.53)

## Copper pours and planes (outline as drawn)
GND on TOP: 1.65,0.89 180.34,0.89 180.34,140.72 1.27,140.72 1.27,108.08
GND on BOTTOM: 1.27,140.59 1.27,1.14 180.21,1.14 180.21,140.72
GND on INNER3: 1.07,141.22 1.2,0.38 126.37,0.38 126.37,64.14 180.85,64.14 180.85,141.22
GND_POWER on INNER3: 126.87,63.5 126.87,1.14 180.85,1.14 180.85,63.5
P48V on INNER4: 126.87,63.5 126.87,1.02 180.85,1.02 180.85,63.5
VCC on INNER4: 180.59,64.14 126.37,64.14 126.37,1.27 1.14,1.27 1.14,140.46 180.59,140.46
Net_1 on BOTTOM (solid shape): 107.09,120.59 105.49,120.59 105.49,121.69 107.09,121.69
Net_2 on BOTTOM (solid shape): 98.55,129.12 96.95,129.12 96.95,130.22 98.55,130.22
Net_3 on BOTTOM (solid shape): 23.88,111.62 21.83,111.62 21.83,115.66 23.88,115.66
Net_4 on BOTTOM (solid shape): 56.45,113.18 54.4,113.18 54.4,117.23 56.45,117.23
Net_5 on BOTTOM (solid shape): 144.97,70.55 142.92,70.55 142.92,74.6 144.97,74.6
Net_6 on BOTTOM (solid shape): 140.89,85.21 138.84,85.21 138.84,89.26 140.89,89.26

## Text on the board
Ref Des/Silkscreen Bottom: SUJ2 | SUJ1 | SUJ3 | SUJ4 | J16
Ref Des/Silkscreen Top: GND | VM+ | SUJ1 | SUJ2 | SUJ3 | SUJ4 | dSIB | DVRK | Rev2
ASSEMBLY_TOP: 7160 | 5590
