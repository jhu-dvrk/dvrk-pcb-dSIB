# Allegro board DSIB_REV3_1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
A3: length 311.4
  TOP w0.127: v1(54.58,111.35) 54.71,111.35 55.22,111.86 56.29,111.86 56.92,111.23 57.05,111.23 57.18,111.1 57.4,111.1 57.53,110.97 57.78,110.97 57.91,110.85 63.35,110.85 64.31,111.81 65.46,111.81 66.01,111.25 95,111.25 95.25,111.51 96.01,111.51 96.27,111.25 116.59,111.25 116.84,111.51 124.33,111.51 124.84,111 v1(151.89,111) ; v1(51.31,110.36) 44.45,110.36 43.18,111.63 v2(42.16,111.63) ; v1(143,76.45) 143,69.72 142.62,69.34 v1(142.24,69.34) 142.24,74.68 141.99,74.93 141.99,77.09 142.75,77.85 148.21,77.85 148.84,77.22 154.18,77.22 154.43,77.47 154.43,78.11 153.03,79.5 153.03,81.03 152.53,81.53 v1(151.89,81.53) ; v1(22.1,108.46) 28.96,108.46 29.21,108.71 32,108.71 32.77,109.47 39.12,109.47 39.37,109.22 v1(52.58,109.22) ; v1(78.49,122.94) 71.5,122.94 70.48,123.95 48.89,123.95 v1(48.39,123.44) v1(48.39,125.22) 48.39,128.78 48.89,129.29 v1(49.02,129.29)
  BOTTOM w0.127: v2(42.16,111.63) 42.67,112.14 42.67,125.86 43.56,126.75 46.86,126.75 v1(48.39,125.22) ; U14.5 48.3,123.25 48.31,123.24 48.39,123.24 v1(48.39,123.44) ; J16.42 64.19,137.23 63.12,138.3 55.24,138.3 49.02,132.08 v1(49.02,129.29) ; v1(142.24,69.34) 142.79,69.34 143.17,69.72 U15.13 143.17,69.8 ; U16.13 54.65,111.41 54.71,111.35 ; v1(151.89,111) v1(151.89,81.53) ; 22.08,110.87 U17.13 22.08,109.08 21.97,108.97 22.1,108.97 v1(22.1,108.46) ; 139.09,84.46 U13.13 139.09,84.45 140.34,83.21 140.34,82.65 142.11,80.9 142.11,77.34 v1(143,76.45) ; v1(78.49,122.94) 78.49,121.67 77.65,120.83 U22.9 ; 53.72,110.36 54.71,111.35 ; 53.72,110.36 v1(51.31,110.36) ; 53.72,110.36 v1(52.58,109.22) ; 54.71,111.35 v1(54.58,111.35)
A3N: length 23.7
  TOP w0.127: v1(63.79,124.97) 66.8,124.97 67.06,124.71 v1(74.04,124.71)
  BOTTOM w0.127: U22.8 74.51,120.18 74.17,120.52 74.17,124.59 v1(74.04,124.71) ; v1(63.79,124.97) 63.75,124.97 63.37,125.35 63.37,129.03 63.79,129.45 J16.8
BRAKE1_VMON: length 5.1
  BOTTOM w0.127: U17.17 20.54,112.86 17.65,109.98 R123.2
BRAKE2_VMON: length 6.4
  BOTTOM w0.127: U16.17 52.96,114.43 52.83,114.31 52.83,114.26 52.71,114.26 52.25,113.79 51.82,113.79 51.56,113.54 51.56,113.03 51.49,113.03 51.33,112.88 51.33,112.4 50.29,111.35 50.29,111.25 50.16,111.25 R122.2
BRAKE3_VMON: length 9.2
  BOTTOM w0.127: R121.2 137.16,67.44 138.46,67.44 138.61,67.59 138.61,68.3 138.89,68.58 140.46,68.58 140.84,68.96 140.84,70.31 141.02,70.48 141.02,71.3 141.53,71.8 U15.17
BRAKE4_VMON: length 6.2
  BOTTOM w0.127: U13.17 136.63,86.46 136.27,86.11 136.27,84.58 136.91,83.95 136.91,83.06 137.41,82.55 R120.2
BST_A: length 6
  TOP w0.508: U26.35 148.33,36.26 148.13,36.45 145.44,36.45 144.81,37.08 144.81,37.11 144.63,37.29 144.02,37.29 C155.1
BST_B: length 2.8
  TOP w0.254: U26.28 152.87,37.22 C149.1
BST_C: length 2.9
  TOP w0.254: C147.2 154.1,37.8 154.1,37.01 153.53,36.43 U26.27
BST_D: length 3.1
  TOP w0.254: U26.20 158.07,36.64 158.7,37.26 C138.2
CLK: length 60.5
  TOP w0.127: v1(105.41,130.3) 105.03,129.92 102.49,129.92 101.6,129.03 98.17,129.03 96.9,127.76 88.77,127.76 88.27,127.25 74.17,127.25 73.41,128.02 72.9,128.02 72.64,127.76 52.45,127.76 v1(52.07,127.38)
  BOTTOM w0.127: v1(105.41,130.3) 105.57,130.14 U18.4 ; U14.10 52.11,124.55 51.82,124.84 51.82,125.6 52.07,125.86 v1(52.07,127.38)
DOUTB0: length 38.6
  TOP w0.127: v1(102.49,130.94) 102.23,131.19 99.57,131.19 98.81,130.43 97.03,130.43 95.63,131.83 90.17,131.83 89.53,132.46 87.88,132.46 86.87,131.44 77.18,131.44 76.45,132.17 J16.24
  BOTTOM w0.127: U18.1 105.28,128.19 105.21,128.12 R74.2 104.01,128.65 104.01,132.46 103.63,132.84 102.62,132.84 102.49,132.72 v1(102.49,130.94)
DOUTB1: length 43.9
  TOP w0.127: v1(105.41,129.29) 103.25,129.29 103.12,129.41 102.62,129.41 101.47,128.27 98.04,128.27 97.28,127.51 89.03,127.51 88.52,127 73.66,127 v1(73.15,127.51)
  BOTTOM w0.127: J16.26 78.07,132.17 76.83,130.94 75.18,130.94 73.15,128.91 v1(73.15,127.51) ; U18.3 106.91,129.41 105.54,129.41 v1(105.41,129.29) 105.16,129.29 105.16,129.36 105.03,129.49 R72.2
DOUTB2: length 33.5
  TOP w0.127: v1(94.61,132.72) 94.74,132.59 99.69,132.59 100.08,132.97 104.01,132.97 v1(104.65,132.33) ; v1(94.23,131.06) 93.85,130.68 79.88,130.68 79.63,130.43 79.5,130.43 v1(79.63,130.3)
  BOTTOM w0.127: v1(104.65,132.33) 104.55,132.33 R71.2 104.61,130.79 104.9,130.79 105.03,130.92 105.79,130.92 105.92,130.79 U18.5 ; v1(94.61,132.72) 94.61,131.44 v1(94.23,131.06) ; J16.28 79.79,130.45 v1(79.63,130.3)
DOUTB3: length 40.5
  TOP w0.127: v1(81.15,130.05) 81.53,130.43 94.36,130.43 95,131.06 95.63,131.06 97.41,129.29 101.47,129.29 102.36,130.18 104.27,130.18 104.9,130.81 105.66,130.81 107.19,129.29 110.62,129.29 111,129.67 v1(111.25,129.67)
  BOTTOM w0.127: v1(81.15,130.05) 81.39,130.05 J16.30 ; R70.2 114.3,131.47 114.3,131.57 113.54,131.57 113.41,131.44 U18.9 111.76,131.44 111.63,131.31 111.63,130.43 111.25,130.05 v1(111.25,129.67)
FAULT: length 40.2
  TOP w0.127: v1(85.85,137.16) 85.85,137.03 85.72,137.16 85.22,136.65 68.33,136.65 68.19,136.52 J16.47
  BOTTOM w0.127: U22.10 77.42,121.48 77.98,122.05 77.98,123.95 86.11,132.08 86.11,136.91 v1(85.85,137.16)
FAULTN: length 241.4
  TOP w0.127: v1(73.66,111.76) 124.71,111.76 124.97,111.51 152.91,111.51 153.42,111 v1(153.42,110.49) ; U26.3 148.98,20.83 v1(148.97,20.83) 148.97,19.99 R110.1 ; v1(74.55,128.52) v1(67.69,128.52) ; v1(136.02,42.29) v1(149.1,42.29) ; v1(153.42,75.44) 153.54,75.44 154.05,74.93 154.05,68.83 153.54,68.33 147.95,68.33 147.07,67.44 135.13,67.44 134.62,66.93 v1(134.62,66.55)
  BOTTOM w0.127: v1(148.97,20.83) 149.1,20.95 149.1,21.84 149.35,22.1 149.35,42.04 v1(149.1,42.29) ; v1(67.69,128.52) 67.79,128.63 J16.13 ; 74.55,125.22 73.79,125.22 73.53,124.97 73.53,111.89 v1(73.66,111.76) ; 74.55,125.22 74.55,122.3 74.72,122.13 U22.11 ; 74.55,125.22 v1(74.55,128.52) ; v1(136.02,42.29) 136.02,63.37 134.62,64.77 v1(134.62,66.55) ; v1(153.42,75.44) 153.42,83.57 153.8,83.95 153.8,84.96 153.42,85.34 v1(153.42,110.49)
I_MOT+: length 6.3
  BOTTOM w0.127: U13.19 136.48,87.46 134.92,85.9 133.83,85.9 ; 133.83,85.9 133.81,85.88 R90.2 ; 133.83,85.9 C134.1
I_MOT-: length 7.8
  BOTTOM w0.127: U13.18 136.63,86.96 134.49,84.84 134.49,83.82 134.47,83.82 R113.2 C156.1
M1: length 5.2
  TOP w0.127: U26.13 155.48,21.13 158.04,18.57 R103.1
M2: length 4.9
  TOP w0.127: R100.1 156.67,19.43 154.83,21.27 U26.12
M3: length 4.6
  TOP w0.127: U26.11 154.18,21.47 155.32,20.32 155.32,18.11 R101.1
MOTOR-1: length 24.4
  TOP w0.508: v1(147.83,118.36) J20.2
  BOTTOM w0.508: J13.6 145.72,131.19 146.56,131.19 147.07,130.68 147.07,119.13 v1(147.83,118.36)
MOTOR-2: length 26
  BOTTOM w0.508: J13.7 148.46,133.73 154.69,133.73 156.84,131.57 156.84,129.03 159.89,125.98 159.89,119.51 J19.2
MOTOR-3: length 25.7
  TOP w0.508: v2(162.94,125.48) 158.75,125.48 155.83,128.4 150.5,128.4 149.99,128.91 J13.8
  BOTTOM w0.508: v2(162.94,125.48) 162.43,124.97 162.43,119.51 J18.2
MOTOR-4: length 24.7
  BOTTOM w0.508: J17.2 162.69,117.22 158.12,117.22 157.61,117.73 157.61,121.92 157.99,122.3 157.99,126.62 155.83,128.78 155.83,130.68 154.05,132.46 J13.9
OTW: length 41.3
  TOP w0.127: v1(83.82,138.43) 83.31,137.92 69.34,137.92 v1(68.83,138.43)
  BOTTOM w0.127: J16.48 68.99,138.43 v1(68.83,138.43) ; v1(83.82,138.43) 83.69,138.3 83.69,138.18 85.85,136.02 85.85,132.21 77.47,123.82 77.47,123.19 77.06,122.78 U22.12
OTWN: length 193.3
  TOP w0.127: v1(140.21,54.36) 139.95,54.36 136.14,58.17 v1(103.63,58.17) ; v1(147.9,23.57) 148.29,23.57 148.33,23.53 U26.2 148.33,20.56 147.57,19.81 147.39,19.81 R112.1 ; v1(69.22,125.98) 70.36,125.98 70.87,126.49 75.82,126.49 76.58,125.73 v1(76.58,124.71) v1(86.87,124.71)
  BOTTOM w0.127: v1(76.58,124.71) 76.58,123.56 76.45,123.43 U22.13 ; J16.14 68.59,131.05 69.22,130.43 v1(69.22,125.98) ; v1(140.21,54.36) 140.34,54.23 140.34,26.92 140.84,26.42 140.84,25.78 143.71,22.91 148.16,22.91 148.26,23.01 148.26,23.55 148.29,23.57 v1(147.9,23.57) ; v1(86.87,124.71) 87,124.59 87,97.66 90.3,94.36 91.88,94.36 92.39,93.85 92.39,86.61 92.65,86.36 93.6,86.36 94.74,87.5 102.36,87.5 102.87,87 102.87,84.45 103.12,84.2 103.12,68.96 103.63,68.45 v1(103.63,58.17)
OUT_A: length 11.4
  TOP w0.508: U26.33 149.63,36.4 148.44,37.59
  TOP w1.27: L7.1 143.26,41.25 144.02,40.49 C155.2 144.5,39.27 146.18,37.59 148.44,37.59
OUT_B: length 8.9
  TOP w0.381: 151.57,36.41 U26.30
  TOP w0.508: C149.2 151.18,39.22 151.16,39.19 151.16,36.83 151.57,36.41
  TOP w0.762: L6.1 150.57,41.25 150.72,41.1 150.72,39.67 151.21,39.19 152.27,39.19 C149.2
OUT_C: length 8.1
  TOP w0.508: 154.74,39.22 154.74,39.19 155.22,38.71 155.22,36.65 154.83,36.26 U26.25
  TOP w0.762: C147.1 155.5,39.22 156.21,39.93 L5.1
OUT_D: length 15.7
  TOP w0.508: C138.1 157.18,37.95 157.18,36.88 157.16,36.86 157.16,36.32 157.03,36.32 157.03,36.19 156.78,36.19 U26.22
  TOP w1.27: L2.1 162.81,41.25 162.43,41.63 162.43,42.04 161.67,42.8 158.24,42.8 157.73,42.29 157.73,39.75 157.35,39.37 157.28,39.37 C138.1
PNET24_5: length 2.7
  TOP w0.61: R102.1 159.26,48.87 C146.2
PNET24_6: length 2.5
  TOP w0.61: R114.1 147.37,48.72 C159.2
POT1: length 54.2
  TOP w0.127: v1(28.19,132.08) 51.56,132.08 52.07,132.59 52.07,135.25 53.59,136.77 53.59,136.78 57.25,136.78 58.34,135.67 J16.35
  BOTTOM w0.127: U17.1 23.58,117.22 23.62,117.22 24,117.6 24,131.57 24.51,132.08 v1(28.19,132.08)
POT2: length 16.5
  BOTTOM w0.127: U16.1 56.15,118.62 56.02,118.75 55.75,118.75 55.24,119.25 55.24,128.78 58.64,132.17 J16.2
POT3: length 152
  TOP w0.127: v1(127.38,85.22) 134.62,85.22 135.13,84.71 137.79,84.71 138.3,85.22 142.88,85.22 v1(143.13,85.47) ; J16.37 59.94,135.67 59.9,135.71 60.83,136.65 62.48,136.65 63.25,137.41 84.07,137.41 85.22,138.56 88.39,138.56 v1(88.77,138.18) ; v1(129.92,126.49) 113.54,126.49 113.28,126.24 107.06,126.24 106.05,127.25 104.01,127.25 103.76,127 100.71,127 100.2,126.49 97.66,126.49 97.28,126.87 96.39,126.87 96.27,126.75 v1(92.71,126.75)
  BOTTOM w0.127: v1(88.77,138.18) 88.77,137.54 92.71,133.6 v1(92.71,126.75) ; v1(127.38,85.22) 127.38,87.88 127.89,88.39 127.89,91.69 127,92.58 127,109.98 129.67,112.65 129.67,126.24 v1(129.92,126.49) ; v1(143.13,85.47) 143.13,83.95 144.53,82.55 144.53,75.97 144.67,75.82 U15.1
POT4: length 122.4
  TOP w0.127: J16.4 60.59,131.18 60.83,130.94 93.09,130.94 93.73,131.57 95.5,131.57 97.41,129.67 101.35,129.67 102.11,130.43 103.12,130.43 103.76,131.06 106.17,131.06 107.57,129.67 109.22,129.67 110.49,130.94 v1(122.94,130.94) ; v1(126.49,115.32) 139.7,115.32 v1(139.83,115.19)
  BOTTOM w0.127: v1(122.94,130.94) 126.62,127.25 126.62,115.44 v1(126.49,115.32) ; U13.1 140.59,90.68 140.46,90.8 140.34,90.8 139.83,91.31 v1(139.83,115.19)
POT-GND-A: length 3.3
  TOP w0.254: J16.58 J16.60
  BOTTOM w0.254: J16.57 76.25,135.67 76.38,135.55 76.38,135.51 76.5,135.51 76.76,135.25 76.76,134.52 J16.58
POT-VCC: length 475.3
  TOP w0.254: 115.57,76.83 115.65,76.91 118.19,76.91 J14.137 ; 115.57,76.83 115.44,76.96 110.62,76.96 J14.33 ; 115.57,76.83 J14.86 ; 19.18,81.86 19.18,79.76 J10.33 ; 19.18,81.86 21.89,81.86 J10.84 23.83,79.93 26.37,79.93 J10.137 30.61,78.36 31.11,77.85 33.4,77.85 33.53,77.72 34.29,77.72 35.69,79.12 39.75,79.12 40.51,79.88 45.09,79.88 45.72,79.25 47.12,79.25 J9.33 ; 19.18,81.86 19.18,82.04 J10.31 ; J16.31 J16.33 ; 83.57,80.9 82.68,81.79 82.68,81.81 82.3,81.81 81.91,82.19 79.5,82.19 79.38,82.32 79.38,82.5 J12.31 77.6,84.28 77.6,84.33 77.47,84.45 v1(70.87,84.45) 70.1,85.22 61.34,85.22 60.58,84.45 60.58,83.69 59.89,83.01 59.23,83.01 58.93,83.31 58.93,83.39 J9.135 57.28,82.5 57.28,82.42 51.94,82.42 ; 83.57,80.9 83.54,80.87 J12.84 ; 83.57,80.9 84.84,82.17 84.84,83.69 85.6,84.45 87.5,84.45 88.01,83.95 88.09,83.95 J12.135 ; v1(89.66,66.67) 98.3,66.67 103.63,61.34 108.08,61.34 v1(108.33,61.09) ; J14.135 118.87,83.95 117.86,83.95 117.47,84.33 110.36,84.33 J14.31 ; J9.84 52.2,81.79 51.94,81.79 51.94,82.42 ; 51.94,82.42 48.01,82.42 J9.31 ; 15.24,23.75 22.86,23.75 23.88,22.73 36.07,22.73 36.58,23.24 36.58,23.32 36.96,23.7 J9.23 J9.49 J9.75 J9.101 53.09,22.73 59.05,22.73 61.59,25.27 74.3,25.27 75.87,23.7 J12.23 J12.49 J12.75 J12.101 83.57,22.73 89.15,22.73 90.3,23.88 97.16,23.88 97.41,23.62 J14.23 J14.49 J14.75 J14.101
  BOTTOM w0.254: J9.135 58.17,82.6 57.2,81.64 57.2,80.06 58.17,79.1 J9.137 58.17,77.52 57.2,76.56 57.2,74.98 58.17,74.02 J9.139 ; J12.31 78.49,82.6 77.52,81.64 77.52,80.06 78.49,79.1 J12.33 78.49,77.52 77.52,76.56 77.52,74.98 78.49,74.02 J12.35 ; J10.86 21.59,77.09 21.59,79.63 J10.84 ; J16.31 82.34,133.32 82.72,132.94 82.72,132.37 82.91,132.17 ; 82.74,132.17 82.66,132.17 82.68,132.16 82.68,131.95 82.74,131.89 82.74,130.62 81.41,129.29 74.3,129.29 73.79,128.78 73.79,126.11 72.77,125.09 72.77,110.87 70.74,108.84 70.74,84.58 v1(70.87,84.45) ; 82.74,132.17 82.91,132.17 ; 82.74,132.17 82.74,132.1 ; J14.31 108.08,82.04 108.08,79.5 J14.33 108.08,76.96 108.08,74.42 J14.35 108.33,72.14 v1(108.33,61.09) 107.82,60.58 107.82,45.97 107.31,45.47 106.05,45.47 105.54,44.96 105.54,20.57 106.05,20.07 107.31,20.07 107.82,20.57 107.82,23.62 J14.23 ; J10.139 27.94,73.15 28.07,73.15 28.07,73.66 29.08,74.68 29.08,76.43 27.94,77.57 J10.137 29.08,79.5 29.08,82.3 J10.135 ; J16.32 82.91,132.17 ; J12.86 83.57,76.56 84.53,77.52 84.53,79.1 83.57,80.06 J12.84 ; J10.35 17.78,73.41 19.18,74.8 19.18,76.96 J10.33 ; J9.35 48.01,74.02 48.97,74.98 48.97,76.56 48.01,77.52 J9.33 48.01,79.1 48.97,80.06 48.97,81.64 48.01,82.6 J9.31 ; J14.137 120.27,77.47 120.27,76.45 120.52,76.2 120.52,74.17 J14.139 ; J12.135 88.65,82.6 87.68,81.64 87.68,80.06 88.65,79.1 J12.137 89.53,77.42 89.53,76.45 89.61,76.45 89.61,75.18 89.48,75.06 89.48,74.17 89.53,74.17 89.53,74.12 J12.139 89.53,72.34 89.53,71.63 89.66,71.5 v1(89.66,66.67) ; J9.84 53.09,80.06 54.05,79.1 54.05,77.52 53.09,76.56 J9.86 ; J14.86 115.7,76.96 115.7,78.74 114.43,80.01 J14.84
PWM: length 199.6
  TOP w0.127: U26.4 149.63,20.04 148.44,18.86 R111.1 147.88,17.53 140.46,17.53 139.95,18.03 v1(139.95,24.64) ; v1(138.81,59.18) v1(154.43,59.18) ; v1(154.43,127) 154.31,127.13 154.18,127.13 153.92,127.38 127.25,127.38 123.19,131.44 v1(118.36,131.44) 117.73,132.08 111.25,132.08 110.24,133.1 106.17,133.1 v1(105.79,132.72)
  BOTTOM w0.127: v1(154.43,127) 154.81,126.62 154.81,94.74 154.94,94.62 154.94,78.49 155.19,78.23 155.19,64.01 155.45,63.75 155.45,60.45 154.43,59.44 v1(154.43,59.18) ; v1(138.81,59.18) 138.81,45.08 139.83,44.07 139.83,25.65 139.95,25.53 v1(139.95,24.64) ; U18.6 105.92,131.44 105.79,131.57 v1(105.79,132.72) ; U18.11 117.86,130.14 118.36,130.65 v1(118.36,131.44)
PWMN: length 166.8
  TOP w0.127: v1(150.5,19.56) 150.75,19.3 150.75,18.47 151.13,18.08 R106.1 ; U26.6 150.93,23.42 v1(151,23.49) ; v1(112.27,110.49) 152.4,110.49 152.91,109.98 v1(157.99,109.98) ; v1(158.5,58.42) 158.5,57.15 160.02,55.63 160.02,53.72 156.34,50.04 155.19,50.04 152.4,47.24 v1(151.64,47.24)
  BOTTOM w0.127: v1(150.5,19.56) 150.62,19.68 150.62,23.11 v1(151,23.49) 151.64,24.13 v1(151.64,47.24) ; v1(158.5,58.42) 158.5,93.98 157.99,94.49 v1(157.99,109.98) ; U18.10 112.01,130.79 111.89,130.67 111.89,130.3 111.76,130.18 111.76,127.76 112.27,127.25 v1(112.27,110.49)
RESETN: length 181.7
  TOP w0.127: R91.2 149.81,17.91 149.94,17.78 149.99,17.78 150.24,17.53 151.51,17.53 151.76,17.78 151.76,18.41 151.26,18.92 151.13,18.92 151,19.05 151,20.32 150.28,21.06 U26.5 150.28,23.46 150.11,23.62 149.86,23.62 ; R107.1 163.02,18.08 163.07,18.03 162.56,17.53 161.75,17.53 161.19,18.08 R105.1 160.78,18.67 160.53,18.92 159.26,18.92 156.97,21.21 156.78,21.21 U26.15 156.78,23.75 156.72,23.75 156.34,24.13 150.37,24.13 149.86,23.62 ; v1(127.51,82.17) 128.14,81.53 135.64,81.53 v1(135.89,81.28) ; 149.86,23.62 v1(148.84,23.62)
  BOTTOM w0.127: U18.8 113.79,132.09 113.92,132.22 113.92,132.72 114.43,133.22 123.19,133.22 128.27,128.14 128.27,113.54 126.75,112.01 126.75,92.46 127.63,91.57 127.63,88.65 126.62,87.63 126.62,83.06 v1(127.51,82.17) ; v1(135.89,81.28) 135.64,81.03 135.64,78.36 135,77.72 135,75.82 132.33,73.15 132.33,71.75 131.83,71.25 131.83,63.12 132.72,62.23 132.72,51.69 132.59,51.56 132.59,25.91 137.03,21.46 148.34,21.46 148.84,21.97 v1(148.84,23.62)
RST: length 64
  TOP w0.127: v1(51.43,126.24) 66.04,126.24 66.55,126.75 76.58,126.75 77.47,125.86 97.03,125.86 97.16,125.98 103.5,125.98 104.52,127 105.03,127 105.28,126.75 v1(105.66,126.75)
  BOTTOM w0.127: v1(105.66,126.75) 107.44,126.75 107.95,127.25 107.95,128.84 U18.2 ; v1(51.43,126.24) 51.43,124.33 51.82,123.95 51.82,123.9 U14.11
SJ1_BRAKE_PWR: length 241.9
  TOP w0.508: v1(32.26,112.52) 20.96,112.52 19.18,114.3 v1(12.32,114.3) ; J10.107 J10.106 24.64,91.06 24.64,91.19 23.62,92.2 21.46,92.2 J10.54 ; J10.3 J10.2 ; v1(143,120.14) 142.75,119.89 124.71,119.89 124.46,120.14 91.44,120.14 91.06,120.52 71.63,120.52 68.96,123.19 54.99,123.19 53.72,121.92 v1(12.45,121.92)
  BOTTOM w0.508: C102.1 13.44,88.52 J10.3 ; 13.33,91.08 15.21,91.08 J10.2 15.75,91.06 16.89,92.2 18.42,92.2 18.92,91.69 18.92,91.31 19.18,91.06 J10.54 J10.55 20.04,88.52 19.53,88.01 19.05,88.01 18.95,87.91 18.95,84.94 18.85,84.84 14.3,84.84 14.17,84.71 13.28,84.71 C113.1 ; 13.33,91.08 C111.1 ; 13.33,91.08 C87.1 ; J13.1 143.05,128.4 143,128.4 v1(143,120.14) ; v1(32.26,112.52) 32.26,108.46 33.27,107.44 33.27,103.12 30.86,100.71 30.86,92.99 C101.1 29.18,92.61 28.96,92.38 26.72,92.38 J10.106 ; J10.107 26.67,87.25 28.32,87.25 28.7,87.63 29.72,87.63 30.23,87.12 C93.1 ; v1(12.45,121.92) 12.32,121.79 v1(12.32,114.3) R67.1
SJ1_BRAKE_RTN: length 211.2
  TOP w0.508: J10.132 26.8,92.2 25.15,92.2 24,93.34 24,97.03 23.5,97.54 23.5,99.95 24,100.46 35.56,100.46 36.07,100.97 36.07,107.95 36.58,108.46 62.23,108.46 62.48,108.2 71.37,108.2 71.63,108.46 98.55,108.46 99.06,108.97 141.73,108.97 142.24,109.47 146.05,109.47 147.07,108.46 159,108.46 159.51,108.97 159.51,112.52 J20.1 ; J10.29 18.29,88.52 19.43,87.38 21.72,87.38 J10.81
  BOTTOM w0.508: 17.78,90.63 J10.29 16.51,87.25 13.59,87.25 C76.1 ; 17.78,90.63 16.94,89.79 13.92,89.79 13.77,89.64 C75.1 ; 17.78,90.63 J10.28 17.96,90.88 17.96,90.8 17.78,90.63 ; 31.24,91.19 31.11,91.06 ; 31.24,91.19 C81.1 28.7,91.24 28.57,91.11 ; 31.24,91.19 C86.1 C67.1 27.97,88.49 J10.133 ; 24.13,89.79 24.23,89.89 26.77,89.89 J10.132 ; 24.13,89.79 J10.80 24,92.2 24,95.63 24.26,95.88 24.26,96.27 24.23,96.27 C108.1 ; 24.13,89.79 J10.81 ; J10.132 28.52,91.06 28.57,91.11 ; J10.132 27.99,91.11 28.57,91.11 ; 28.57,91.11 31.11,91.11
SJ1_BRK_REL: length 54.6
  TOP w0.127: v1(91.44,133.73) 91.44,134.11 89.15,136.4 69.34,136.4 68.96,136.02 68.96,135.51 69.72,134.75 69.72,134.24 70.64,133.32 J16.17 ; v1(91.69,123.44) 99.06,123.44 99.44,123.06 100.33,123.06 100.46,123.19 106.43,123.19 v1(106.68,123.44)
  BOTTOM w0.127: v1(106.68,123.44) 106.68,123.19 106.79,123.19 U20.12 ; v1(91.69,123.44) 91.69,129.16 91.44,129.41 v1(91.44,133.73)
SJ1_GND_SENSEN: length 158.8
  TOP w0.127: v1(43.94,69.34) 21.46,69.34 J10.63 ; v1(99.06,98.55) 101.85,98.55 v1(102.11,98.3) ; v1(99.06,89.79) 99.06,89.66 96.65,87.25 77.85,87.25 77.34,87.76 77.34,95.25 77.09,95.5 v1(52.58,95.5)
  BOTTOM w0.127: v1(99.06,89.79) v1(99.06,98.55) ; v1(102.11,98.3) 103.25,99.44 107.7,99.44 109.73,101.47 109.73,121.92 109.22,122.43 107.29,122.43 U20.13 ; v1(43.94,69.34) 43.94,82.17 42.93,83.19 42.93,84.07 43.43,84.58 51.31,84.58 51.82,85.09 51.82,95 52.32,95.5 v1(52.58,95.5)
SJ1_POT1: length 8.7
  TOP w0.127: v1(12.06,76.96) 12.01,76.91 12.14,76.91 14.48,79.25 16.13,79.25 J10.32
  BOTTOM w0.127: v1(12.06,76.96) 11.84,76.96 11.82,76.98 U6.1 11.82,77.94
SJ1_POT2: length 16.6
  TOP w0.127: J10.85 23.75,77.47 33.27,77.47 33.66,77.09 v1(33.91,77.09)
  BOTTOM w0.127: v1(33.91,77.09) 33.66,76.83 33.66,73.91 33.91,73.66 34.04,73.66 34.04,73.58 35.25,73.58
SJ1_POT3: length 29.7
  TOP w0.127: v1(16.87,99.21) 17.02,99.06 17.02,97.03 16.64,96.65 16.64,87.38 17.14,86.87 20.96,86.87 21.46,86.36 21.46,82.83 22.12,82.17 26.67,82.17 J10.136
  BOTTOM w0.127: U1.4 16.66,99.52 16.61,99.47 16.74,99.47 16.74,99.34 v1(16.87,99.21)
SJ1_POT4: length 18.6
  TOP w0.127: v1(10.49,81.94) 10.31,81.94 8.64,80.26 8.64,75.69 8.79,75.54 10.95,75.54 11.56,74.93 13.61,74.93 14.22,75.54 14.22,76.5 14.68,76.96 16.64,76.96 J10.34
  BOTTOM w0.127: 10.36,81.94 v1(10.49,81.94)
SJ1_POT5: length 13.4
  TOP w0.127: J10.87 24,74.42 33.53,74.42 v1(34.29,75.18)
  BOTTOM w0.127: v1(34.29,75.18) 34.54,74.93 34.54,75.08 U12.12
SJ1_POT6: length 30.9
  TOP w0.127: v1(22.61,98.93) 22.61,95.25 v1(22.86,95)
  BOTTOM w0.127: J10.138 26.54,77.22 26.54,84.33 26.16,84.71 24.38,84.71 24.13,84.96 24.13,86.87 23.75,87.25 21.97,87.25 21.59,87.63 21.59,94.11 22.48,95 v1(22.86,95) ; v1(22.61,98.93) 22.02,99.52 U1.9
SJ1_POT11: length 32.9
  TOP w0.127: v1(12.14,81.94) 11.89,82.19 11.89,82.35 11.79,82.45 8.03,82.45 7.32,81.74 7.32,81.71 7.06,81.46 v1(7.44,81.46) ; J10.36 17.02,70.74 16,71.75 14.6,71.75 14.35,71.5 14.35,68.71 13.84,68.2 12.95,68.2 12.7,68.45 12.7,73.41 11.18,74.93 v1(10.52,74.93)
  BOTTOM w0.127: U6.12 11.82,81.87 11.89,81.94 v1(12.14,81.94) ; v1(10.52,74.93) 10.26,75.18 8.76,75.18 7.39,76.56 7.39,81.38 7.32,81.46 v1(7.44,81.46)
SJ1_POT12: length 37.7
  TOP w0.127: v1(20.57,95.88) 20.57,95.12 19.43,93.98 19.43,90.17 19.94,89.66 23.24,89.66 23.75,89.15 23.75,87.38 24.26,86.87 v1(29.46,86.87)
  BOTTOM w0.127: v1(20.57,95.88) 20.45,96.01 20.45,97.89 20.57,98.02 U1.12 ; J10.140 29.46,72.26 v1(29.46,86.87)
SJ1_POT13: length 62
  TOP w0.127: v1(13.56,76.3) 10.97,76.3 10.36,76.91 v1(10.41,76.96)
  BOTTOM w0.127: v1(13.56,76.3) 13.16,76.3 13.06,76.2 13.06,69.88 13.72,69.22 13.72,66.8 13.46,66.55 13.46,38.23 14.48,37.21 14.48,36.58 14.35,36.45 ; 15.24,36.45 14.35,36.45 ; 14.35,36.45 13.84,36.45 13.84,22.45 14.45,21.84 14.48,21.84 15.11,21.21 15.24,21.21 ; 10.45,77 v1(10.41,76.96)
SJ1_POT14: length 84.6
  TOP w0.127: v1(13.21,68.71) 14.1,69.6 14.1,73.41 15.37,74.68 28.45,74.68 29.46,75.69 v1(38.35,75.69)
  BOTTOM w0.127: U12.1 38.23,75.08 38.35,75.21 v1(38.35,75.69) ; v1(13.21,68.71) 13.21,21.34 14.48,20.07 17.78,20.07 17.78,21.21
SJ1_POT15: length 64.9
  BOTTOM w0.127: 20.32,21.21 21.59,22.48 30.35,22.48 37.85,29.97 37.85,73.33 38.1,73.58 38.15,73.58
SJ1_POT16: length 100.5
  TOP w0.127: v1(16.51,97.54) v1(9.65,97.54)
  BOTTOM w0.127: 22.86,21.21 21.46,19.81 12.45,19.81 11.68,20.57 11.68,58.67 6.86,63.5 6.86,82.8 9.65,85.6 v1(9.65,97.54) ; U1.1 17.02,98.02 17.02,97.92 16.64,97.54 v1(16.51,97.54)
SJ1_POTF1: length 5.9
  BOTTOM w0.127: U17.9 25,112.36 25.5,111.86 25.5,111.51 25.78,111.23 26.67,111.23 26.67,111.12 27.3,111.12 C64.1 R60.2
SJ1_POTF2: length 5.3
  BOTTOM w0.127: R54.2 C59.1 27.51,112.34 25.58,112.34 25.06,112.86 U17.8
SJ1_POTF3: length 5.4
  BOTTOM w0.127: R42.2 C50.1 27.48,112.62 25.7,112.62 24.96,113.37 U17.7
SJ1_POTF4: length 5.1
  BOTTOM w0.127: U17.6 27.35,113.86 C43.1 R35.2
SJ1_POTF5: length 5.5
  BOTTOM w0.127: U17.5 25.06,114.36 25.83,115.14 26.67,115.14 26.67,115.19 27.3,115.19 C44.1 R34.2
SJ1_POTF6: length 6.4
  BOTTOM w0.127: R25.2 C32.1 27.64,116.89 27.64,116.84 27.43,116.64 25.91,116.64 25.48,116.21 25.48,115.27 25.07,114.86 U17.4
SJ1_POTF7: length 9.3
  BOTTOM w0.127: U17.3 25.04,115.36 25.22,115.54 25.22,119.25 25.48,119.51 26.39,119.51 26.54,119.35 27.81,119.35 28.04,119.13 C22.1 R17.2
SJ1_POTF8: length 10.6
  BOTTOM w0.127: U17.2 24.56,115.88 24.56,120.32 25.4,121.16 27.71,121.16 28.04,120.83 C12.1 R9.2
SJ1_POTF9: length 5.7
  BOTTOM w0.127: R27.2 17.22,117.98 17.6,118.36 19.43,118.36 19.74,118.06 19.74,117.65 C33.1 19.79,117.6 21.08,116.31 U17.23
SJ1_POTF10: length 7
  BOTTOM w0.127: U17.22 20.75,115.36 19.96,116.15 19.74,116.15 C34.1 19.61,116.13 19.35,116.13 19.2,116.28 19.2,117.96 19.05,118.11 18.08,118.11 17.96,117.98 17.96,117.27 17.37,116.69 R26.2
SJ1_POTF11: length 5.9
  BOTTOM w0.127: R36.2 17.78,115.32 17.91,115.19 17.91,113.41 18.03,113.28 19.05,113.28 19.18,113.41 19.18,114.43 C45.1 19.88,114.87
SJ1_POTF12: length 5.5
  BOTTOM w0.127: 21.08,114.37 20.36,114.37 19.94,113.94 19.74,113.94 19.69,113.89 C51.1 19.74,113.74 19.74,113.39 19.38,113.03 17.65,113.03 17.3,113.39 17.3,113.94 R43.2
SJ1_PRESENTN: length 120
  TOP w0.127: v1(60.45,60.2) 39.37,60.2 39.37,63.25 38.86,63.75 v1(32,63.75)
  BOTTOM w0.127: v1(32,63.75) R69.2 30.61,68.22 30.61,68.2 J10.141 ; v1(60.45,60.2) 60.58,60.33 60.58,78.74 61.59,79.76 61.59,81.79 61.85,82.04 62.99,82.04 63.25,81.79 66.29,81.79 67.69,83.19 67.69,122.05 66.19,123.5 J16.11
SJ1_REL: length 167.8
  TOP w0.127: J10.62 21.46,69.6 38.35,69.6 40.89,72.14 40.89,75.18 41.27,75.56 v1(42.54,75.56) ; v1(41.4,122.81) 53.34,122.81 54.23,123.7 69.6,123.7 71.88,121.41 91.69,121.41 92.46,120.65 v1(125.22,120.65)
  BOTTOM w0.127: 125.35,117.6 125.73,117.22 126.03,117.22 R73.2 ; 125.35,117.6 125.22,117.73 v1(125.22,120.65) ; 125.35,117.6 124.84,117.09 124.84,116.84 124.71,116.71 124.71,116.69 U27.1 ; v1(42.54,75.56) 42.42,75.69 42.42,79.25 41.27,80.39 41.27,94.62 40.13,95.76 40.13,116.59 41.4,117.86 v1(41.4,122.81)
SJ1_RELN: length 152.8
  TOP w0.127: v1(42.93,64.01) 32.51,64.01 32.26,64.26 21.46,64.26 J10.65 ; v1(107.19,117.09) 107.19,117.35 106.68,117.86 56.9,117.86 55.75,119 52.7,119 49.53,115.82 v1(43.69,115.82)
  BOTTOM w0.127: v1(43.69,115.82) 43.18,115.32 43.18,112.4 43.56,112.01 43.56,109.6 45.47,107.7 45.85,107.7 47.12,106.43 47.12,95.76 48.89,93.98 48.89,87.38 48.39,86.87 43.18,86.87 42.67,86.36 42.67,82.68 43.69,81.66 43.69,74.42 43.18,73.91 43.18,64.26 v1(42.93,64.01) ; v1(107.19,117.09) 107.29,117.09 R81.2 U20.2
SJ1_SPARE1: length 102.2
  TOP w0.127: v1(8.13,112.27) 8.25,112.4 18.03,112.4 v1(18.16,112.52) ; 22.86,46.61 22.86,49.53 22.35,50.04 v1(9.14,50.04)
  BOTTOM w0.127: v1(9.14,50.04) 9.02,50.04 4.83,54.23 4.83,81.15 9.14,85.47 9.14,89.79 6.6,92.33 6.6,110.74 v1(8.13,112.27) ; 22.86,46.61 22.86,48.72 C124.1 ; U17.19 20.65,113.87 19.18,112.4 17.4,112.4 17.27,112.52 ; R44.2 17.27,112.52 ; 17.27,112.52 v1(18.16,112.52)
SJ1_SPARE2: length 87.1
  TOP w0.127: v2(27.18,95.25) 30.61,95.25 31.62,94.23 31.62,93.34 32.26,92.71 v1(32.26,84.96) ; v1(18.29,111.38) 18.64,111.38 18.67,111.35 18.67,111.25 23.88,111.25 v1(24.38,110.74)
  BOTTOM w0.127: v2(27.18,95.25) 27.18,99.57 24.64,102.11 24.64,110.49 v1(24.38,110.74) ; 18.26,111.35 v1(18.29,111.38) ; 18.26,111.35 R55.2 ; 18.26,111.35 18.54,111.35 20.55,113.37 U17.18 ; v1(32.26,84.96) 32.26,68.96 32.51,68.71 32.51,50.04 32,49.53 26.04,49.53 C123.1 25.4,48.79 25.4,46.61
SJ2_BRAKE_PWR: length 202.3
  TOP w0.508: 45.47,89.28 46.28,89.28 46.56,89.56 47.37,89.56 ; 45.47,89.28 J9.3 ; 45.47,89.28 J9.2 ; 55.63,89.28 J9.106 ; 55.63,89.28 J9.107 ; 55.63,89.28 54.81,89.28 54.53,89.56 50.55,89.56 ; 50.55,89.56 49.53,89.56 ; 50.55,89.56 J9.55 49.53,89.53 49.53,89.56 ; 49.53,89.56 47.37,89.56 ; 47.37,89.56 46.86,90.07 46.86,97.28 47.37,97.79 67.82,97.79 71.12,101.09 96.27,101.09 103.5,108.33 145.29,108.33 v1(145.54,108.59)
  BOTTOM w0.508: C80.1 56.92,92.3 J9.106 ; v1(145.54,108.59) 145.54,128.14 145.8,128.4 145.82,128.4 J13.2 ; 50.55,95.76 50.85,95.76 C72.1 ; 50.55,95.76 50.55,94.74 49.89,94.74 49.38,94.23 49.38,92.33 50.55,91.16 J9.54 J9.55 ; 50.55,95.76 49.5,95.76 49.25,96.01 49.25,96.7 C73.1 48.18,96.72 47.62,97.28 47.62,107.19 46.61,108.2 45.85,108.2 44.07,109.98 44.07,112.27 44.58,112.78 45.72,112.78 46.1,113.16 46.02,113.16 R66.1 ; J9.2 45.39,90.93 C100.1 ; C99.1 59.82,87.2 56.9,87.2 J9.107 ; C107.1 45.42,88.34 45.47,88.39 J9.3
SJ2_BRAKE_RTN: length 178.3
  TOP w0.508: 51.82,92.1 49.02,92.1 49.02,92.08 J9.28 ; 51.82,92.1 51.94,92.1 51.94,92.08 52.07,92.08 53.09,91.06 J9.80 ; 51.82,92.1 51.82,96.27 52.7,97.16 v1(75.44,97.16) ; J19.1 157.99,116.59 157.48,116.59 157.1,116.97 155.19,116.97 154.81,117.35 108.97,117.35 107.95,116.33 v1(78.49,116.33)
  BOTTOM w0.508: v1(75.44,97.16) 75.44,98.81 78.49,101.85 v1(78.49,116.33) ; 60.2,89.74 C84.1 58.24,90.93 J9.132 ; 60.2,89.74 C91.1 60.2,88.47 ; 60.2,89.74 53.09,89.74 ; C98.1 60.2,88.47 ; 60.2,88.47 J9.133 ; 53.09,89.74 J9.81 54.1,87.45 54.1,87.15 54.15,87.15 54.41,86.89 54.41,85.09 54.86,84.63 58.67,84.63 59.18,85.14 59.18,85.19 59.44,85.45 C106.1 ; 53.09,89.74 J9.80 ; J9.29 48.01,89.74 ; 48.01,89.74 J9.28 46.71,92.3 C92.1 ; 48.01,89.74 41.78,89.74 C85.1
SJ2_BRK_REL: length 42.9
  TOP w0.127: v1(102.23,121.67) 98.81,121.67 97.54,122.94 82.8,122.94 81.53,124.21 76.33,124.21 76.07,124.46 76.07,125.22 75.56,125.73 v1(71.75,125.73)
  BOTTOM w0.127: v1(102.23,121.67) 104.01,119.89 U20.6 ; v1(71.75,125.73) 71.79,125.76 J16.18
SJ2_GND_SENSEN: length 124.8
  TOP w0.127: v1(53.34,96.01) 66.8,96.01 67.06,95.76 77.22,95.76 77.6,95.38 77.6,89.92 78.11,89.41 78.87,89.41 79.38,88.9 79.38,88.01 79.88,87.5 86.87,87.5 87.38,88.01 87.38,94.74 87.88,95.25 90.04,95.25 92.08,93.22 94.11,93.22 96.27,95.38 96.27,98.68 97.03,99.44 99.44,99.44 99.82,99.82 100.84,99.82 101.09,100.08 101.85,100.08 102.11,99.82 107.06,99.82 v1(107.19,99.95)
  BOTTOM w0.127: J9.63 51.31,68.96 51.69,69.34 51.69,80.77 52.2,81.28 52.2,93.98 53.09,94.87 53.09,95.76 v1(53.34,96.01) ; U20.5 105.79,119.13 105.66,119.13 105.66,109.85 108.46,107.06 108.46,101.22 v1(107.19,99.95)
SJ2_POT1: length 12.8
  TOP w0.127: v1(40,80.39) 39.88,80.39 39.75,80.26 43.56,80.26 45.09,81.79 48.01,81.79 J9.32
  BOTTOM w0.127: U4.1 37.49,80.04 37.85,80.39 v1(40,80.39)
SJ2_POT2: length 14.8
  TOP w0.127: J9.85 53.85,77.47 53.97,77.34 53.97,74.68 54.48,74.17 58.55,74.17 59.56,73.15 v1(64.01,73.15)
  BOTTOM w0.127: 63.88,73.03 v1(64.01,73.15)
SJ2_POT3: length 11.2
  TOP w0.127: v1(66.17,77.22) 63.75,77.22 63.25,77.72 63.25,80.34 62.74,80.85 J9.136
  BOTTOM w0.127: 66.29,77.22 v1(66.17,77.22)
SJ2_POT4: length 20.7
  TOP w0.127: v1(35.97,83.92) 36.7,83.19 39.5,83.19 41.15,81.53 v1(43.05,81.53) ; v1(43.18,74.85) 43.05,74.98 43.05,75.11 43.03,75.13 44.73,75.13 44.98,74.88 47.24,74.88 47.24,74.93 J9.34
  BOTTOM w0.127: v1(43.18,74.85) 43.05,74.98 v1(43.05,81.53) ; 35.99,83.9 v1(35.97,83.92)
SJ2_POT5: length 13.8
  TOP w0.127: v1(64.9,73.41) 64.9,73.15 64.39,72.64 64.01,72.64 63.63,72.26 54.1,72.26 53.97,72.39 53.85,72.39 J9.87
  BOTTOM w0.127: U11.12 65.15,72.64 64.9,72.9 v1(64.9,73.41)
SJ2_POT6: length 13.5
  TOP w0.127: J9.138 60.96,75.77 61.47,76.28 v1(61.47,76.33)
  BOTTOM w0.127: 66.47,80.98 66.47,81.15 66.22,81.41 66.17,81.41 66.04,81.53 63.25,81.53 62.74,81.03 62.74,76.83 62.23,76.33 v1(61.47,76.33)
SJ2_POT11: length 25.5
  TOP w0.127: v1(44.04,83.92) v1(38.51,83.92)
  BOTTOM w0.127: J9.36 47.24,71.5 47.24,71.58 47.12,71.7 47.12,81.56 46.35,82.32 46.35,84.18 46.25,84.28 43.89,84.28 43.56,83.95 43.31,83.95 43.28,83.92 v1(44.04,83.92) ; v1(38.51,83.92) 37.85,83.92 37.49,83.57 U4.12
SJ2_POT12: length 22.5
  TOP w0.127: J9.140 58.17,71.63 64.9,71.63 65.41,72.14 65.41,73.41 65.91,73.91 67.82,73.91 69.22,75.31 69.22,77.72 68.58,78.36 68.58,81.53 v1(68.2,81.91)
  BOTTOM w0.127: 67.97,81.91 67.94,81.91 67.97,81.94 67.97,81.91 ; 67.97,81.91 U8.12 ; 67.97,81.91 v1(68.2,81.91)
SJ2_POT13: length 23.8
  TOP w0.127: v1(42.21,40.03) 43.46,40.03 43.56,39.93 43.56,36.5 43.66,36.4 J9.18
  BOTTOM w0.127: J9.24 44.81,21.82 44.78,21.79 44.78,21.41 44.68,21.31 44.65,21.31 44.58,21.39 44.58,35.51 J9.18 ; 42.24,40.03 v1(42.21,40.03)
SJ2_POT14: length 74.7
  TOP w0.127: v1(63.4,23.11) 63.4,21.95 61.47,20.02 49.15,20.02 J9.50 ; v1(63.14,68.68) 68.58,68.68 68.68,68.78 68.68,69.85 68.94,70.1 68.94,70.87 68.68,71.12 68.68,72.44 v1(69.04,72.8)
  BOTTOM w0.127: v1(63.14,68.68) 63.42,68.68 63.53,68.58 63.53,24.49 63.35,24.31 63.35,23.16 v1(63.4,23.11) ; v1(69.04,72.8) 68.88,72.64 U11.1
SJ2_POT15: length 67.6
  TOP w0.127: v1(69.19,24.64) 63.5,24.64 60.91,22.05 51.43,22.05 J9.76
  BOTTOM w0.127: 68.17,71.15 69.17,71.15 69.16,71.12 69.16,24.64 v1(69.19,24.64)
SJ2_POT16: length 74.6
  TOP w0.127: J9.102 53.97,20.27 61.01,20.27 62.61,21.87 62.61,23.16 63.07,23.62 63.45,23.62 v1(63.86,24.03)
  BOTTOM w0.127: v1(63.86,24.03) 63.88,24.05 63.88,67.89 63.91,67.92 63.91,69.09 62.94,70.05 62.94,74.93 63.32,75.31 64.52,75.31 65.02,75.82 65.02,76.38 65.35,76.71 65.71,76.71 65.84,76.58 66.29,76.58 66.55,76.33 67.82,76.33 68.07,76.07 68.83,76.07 69.09,76.33 69.09,76.83 68.07,77.85 67.97,77.85 U8.1
SJ2_POTF1: length 8.6
  BOTTOM w0.127: R50.2 C57.1 61.39,111.33 59.23,111.33 58.67,111.89 58.67,113.6 58.47,113.79 58.33,113.93 U16.9
SJ2_POTF2: length 7.7
  BOTTOM w0.127: R49.2 C56.1 61.37,112.67 59.44,112.67 58.93,113.18 58.93,113.92 58.68,114.17 58.42,114.17 58.16,114.43 U16.8
SJ2_POTF3: length 7.1
  BOTTOM w0.127: U16.7 58.17,114.94 58.55,114.55 59.18,114.55 59.44,114.3 59.44,114.22 59.82,113.84 60.33,113.84 60.58,114.1 61.42,114.1 C48.1 R40.2
SJ2_POTF4: length 6.7
  BOTTOM w0.127: R32.2 C41.1 61.98,116.03 61.98,115.7 61.72,115.44 57.66,115.44 57.65,115.43 U16.6
SJ2_POTF5: length 7.1
  BOTTOM w0.127: U16.5 58.28,115.93 59.05,116.71 61.72,116.71 61.98,116.97 61.98,117.4 C30.1 R23.2
SJ2_POTF6: length 7.2
  BOTTOM w0.127: R15.2 C19.1 61.47,118.11 59.44,118.11 57.76,116.43 U16.4
SJ2_POTF7: length 14.5
  TOP w0.127: v1(65.23,120.07) 65.23,119.89 64.72,119.38 60.58,119.38 60.58,119.41 59.31,119.41 59.18,119.28 v1(58.98,119.28)
  BOTTOM w0.127: 63.35,120.19 63.86,120.7 64.72,120.7 65.23,120.19 v1(65.23,120.07) ; 63.35,120.19 63.35,120.17 63.22,120.04 C18.1 ; 63.35,120.19 63.4,120.14 R14.2 ; v1(58.98,119.28) 58.32,119.28 57.91,118.87 57.91,117.19 57.66,116.93 U16.3
SJ2_POTF8: length 8.8
  BOTTOM w0.127: U16.2 57.15,118.87 58.78,120.5 60.33,120.5 60.58,120.75 60.58,120.78 61.39,120.78 C63.1 R59.2
SJ2_POTF9: length 7.7
  BOTTOM w0.127: R16.2 C21.1 49.12,119.51 50.93,119.51 52.96,117.47 52.96,117.43 U16.23
SJ2_POTF10: length 7
  BOTTOM w0.127: R24.2 C31.1 49.02,116.89 51.36,116.89 51.66,117.2 52.32,117.2 52.59,116.93 U16.22
SJ2_POTF11: length 7.4
  BOTTOM w0.127: R33.2 C42.1 49.02,115.52 49.45,115.52 49.78,115.19 51.56,115.19 52.53,116.15 52.55,116.15 52.83,116.43 U16.21
SJ2_POTF12: length 7.7
  BOTTOM w0.127: U16.20 53.2,115.93 51.82,114.55 51.18,114.55 50.93,114.3 50.8,114.3 50.8,114.25 50.67,114.25 50.42,114 49.17,114 C49.1 R41.2
SJ2_PRESENTN: length 76
  TOP w0.127: v1(61.59,83.95) 62.48,84.84 68.83,84.84 v1(69.22,84.45) ; v1(59.94,69.09) 59.94,68.66 59.44,68.15 J9.141
  BOTTOM w0.127: R68.2 59.99,69.04 v1(59.94,69.09) 59.82,69.22 59.82,82.68 61.09,83.95 v1(61.59,83.95) ; J16.12 66.99,125.17 69.22,122.94 v1(69.22,84.45)
SJ2_REL: length 212.4
  TOP w0.127: v1(79.38,61.98) 68.83,61.98 66.29,64.52 52.2,64.52 51.69,65.02 51.69,68.96 51.31,69.34 51.31,69.85 J9.62 ; v1(79.38,59.69) 114.81,59.69 115.32,60.2 120.14,60.2 120.4,60.45 150.37,60.45 153.42,63.5 156.21,63.5 156.46,63.25 157.35,63.25 157.86,63.75 157.86,94.87 157.35,95.38 v1(131.95,95.38) ; v1(126.62,113.41) v1(131.95,113.41)
  BOTTOM w0.127: v1(126.62,113.41) 126.62,114.55 126.54,114.68 125.81,114.68 125.15,115.39 U27.3 ; v1(131.95,113.41) v1(131.95,95.38) ; v1(79.38,61.98) v1(79.38,59.69) 79.38,50.93 79.32,50.88 R83.2
SJ2_RELN: length 147.8
  TOP w0.127: v1(61.47,82.8) 60.71,82.04 57.78,82.04 57.28,81.53 57.28,79.76 56.77,79.25 50.16,79.25 49.66,78.74 49.66,69.6 50.16,69.09 50.93,69.09 51.43,68.58 51.43,64.01 51.31,63.88 51.31,63.83 J9.65 51.31,62.31 51.31,61.21 51.56,60.96 66.29,60.96 73.15,54.1 v1(77.72,54.1) ; v1(63.63,109.09) 63.75,108.97 98.42,108.97 98.93,109.47 105.66,109.47 106.17,109.98 v1(106.17,110.11)
  BOTTOM w0.127: v1(63.63,109.09) 63.63,108.84 63.5,108.71 63.5,99.31 63.25,99.06 63.25,98.04 63.37,97.92 63.37,84.71 v1(61.47,82.8) ; U20.4 106.29,117.09 106.17,117.09 v1(106.17,110.11) ; v1(77.72,54.1) 77.72,50.77 77.95,50.55 R84.2
SJ2_SPARE1: length 89.3
  TOP w0.127: v1(50.42,113.41) 50.8,113.79 52.32,113.79 52.83,113.28 52.83,111.89 53.34,111.38 54.08,111.38 54.08,111.3 53.7,110.92 53.82,110.92 53.82,110.79 53.7,110.79 54.05,110.44 54.1,110.44 54.1,110.49 v1(54.86,110.49)
  BOTTOM w0.127: v1(54.86,110.49) 54.86,97.79 55.37,97.28 62.23,97.28 62.74,96.77 62.74,85.98 61.09,84.33 59.44,84.33 59.18,84.07 59.18,60.45 53.09,54.36 53.09,48.87 ; 53.09,48.87 C122.1 ; 53.09,48.87 J9.92 ; R52.2 50.42,113.33 v1(50.42,113.41) 50.8,113.79 50.93,113.79 51.43,114.3 51.94,114.3 53.08,115.44 U16.19
SJ2_SPARE2: length 84.9
  TOP w0.127: v1(61.47,94.87) 59.56,94.87 59.18,94.49 59.18,84.33 v1(59.69,83.82)
  BOTTOM w0.127: U16.18 52.96,114.94 52.07,114.05 51.56,114.05 51.05,113.54 51.05,113.03 50.42,112.4 50.42,112.34 50.04,111.96 R53.2 49.53,111.38 49.4,111.25 49.28,111.25 49.02,111 49.02,103 54.99,97.03 59.31,97.03 v1(61.47,94.87) ; J9.118 C121.1 55.63,49.4 55.75,49.53 58.93,49.53 59.44,50.04 59.44,83.57 v1(59.69,83.82)
SJ3_BRAKE_PWR: length 215.4
  TOP w0.508: J12.107 86.11,90.2 ; 86.11,90.2 85.29,90.2 85.01,89.92 81.03,89.92 J12.54 ; 86.11,90.2 J12.106 ; v1(90.42,67.31) 98.93,67.31 104.39,61.85 128.91,61.85 129.03,61.98 132.08,61.98 v1(133.35,63.25) 133.35,63.75 134.37,64.77 134.87,64.77 135.64,64.01 152.27,64.01 153.42,65.15 v1(153.54,65.15) ; J12.3 J12.2
  BOTTOM w0.508: 90.17,87.25 87.38,87.25 86.94,87.68 86.89,87.68 J12.107 ; 90.17,87.25 90.7,87.25 90.98,86.97 C95.1 ; 90.17,87.25 89.92,87 89.92,81.66 90.42,81.15 v1(90.42,67.31) ; 73.61,87.22 C97.1 ; 73.61,87.22 79.86,87.22 81.03,88.39 J12.55 J12.54 80.01,92.08 79.76,92.33 79.76,95 79.86,95.1 C79.1 ; 73.61,87.22 73.61,88.47 ; C83.1 73.84,91.01 J12.2 ; 73.61,88.47 C90.1 ; 73.61,88.47 J12.3 ; J13.3 149.86,130.94 152.4,130.94 152.91,130.43 152.91,129.03 153.03,128.91 153.03,111.89 154.18,110.74 154.18,109.98 153.92,109.73 153.92,85.47 154.31,85.09 154.31,78.49 154.69,78.11 154.69,65.66 154.18,65.15 v1(153.54,65.15) ; v1(133.35,63.25) 133.35,67.82 134.9,69.37 R65.1 ; C96.1 87.38,92.3 J12.106
SJ3_BRAKE_RTN: length 157.7
  TOP w0.508: 82.55,92.1 82.55,92.08 J12.80 82.47,92.1 79.65,92.1 ; 79.65,92.1 79.58,92.1 J12.28 78.56,91.01 79.65,92.1 ; 79.65,92.1 79.76,92.2 79.76,93.85 76.71,96.9 76.71,98.68 78.49,100.46 98.3,100.46 98.68,100.84 106.3,100.84 106.43,100.97 108.33,100.97 108.46,100.84 154.81,100.84 155.07,100.58 160.78,100.58 161.29,101.09 J18.1
  BOTTOM w0.508: J12.81 83.57,89.71 ; 83.57,89.71 C82.1 ; 83.57,89.71 J12.80 84.58,92.02 84.58,92.08 84.89,92.38 C78.1 ; C82.1 C104.1 91.74,88.49 88.67,88.49 J12.133 ; C82.1 C89.1 91.82,91.01 J12.132 ; J12.29 78.49,89.71 ; 78.49,89.71 J12.28 77.17,92.33 74.07,92.33 73.79,92.61 C71.1 ; 78.49,89.71 73.76,89.71 C105.1
SJ3_BRK_REL: length 54.7
  TOP w0.127: v1(71.12,138.56) 71.25,138.43 82.93,138.43 83.95,139.45 90.04,139.45 90.55,138.94 90.55,135.76 92.71,133.6 95,133.6 95.5,133.1 99.06,133.1 99.44,133.48 100.84,133.48 v1(102.23,134.87)
  BOTTOM w0.127: U20.8 104.67,121.39 104.14,121.92 104.14,123.7 102.74,125.09 102.74,127.13 101.85,128.02 101.85,129.16 101.98,129.29 101.98,134.11 102.23,134.37 v1(102.23,134.87) ; J16.51 71.39,138.29 v1(71.12,138.56)
SJ3_GND_SENSEN: length 81.5
  TOP w0.127: v1(85.98,123.57) 86.36,123.95 99.57,123.95 99.95,124.33 99.95,124.97 100.2,125.22 102.36,125.22 103.25,124.33 v1(106.17,124.33)
  BOTTOM w0.127: J12.63 81.79,68.96 82.3,69.47 82.3,83.69 82.55,83.95 82.55,96.14 82.17,96.52 82.17,97.79 85.85,101.47 85.85,123.44 v1(85.98,123.57) ; v1(106.17,124.33) 106.17,123.06 106.29,123.06 U20.11
SJ3_POT1: length 19
  TOP w0.127: v1(94.34,80.26) 94.34,80.24 93.68,79.58 87.68,79.58 87.33,79.93 82.93,79.93 82.8,80.06 82.75,80.06 82.17,80.64 82.17,81.41 81.79,81.79 79.76,81.79 79.25,81.28 79.25,81.08 78.99,80.85 J12.32
  BOTTOM w0.127: v1(94.34,80.26) 94.34,80.39 94.31,80.39 94.18,80.52 U2.1
SJ3_POT2: length 61.5
  TOP w0.127: v1(82.17,62.1) 92.96,62.1 93.6,62.74 101.35,62.74 v1(101.6,62.48)
  BOTTOM w0.127: v1(101.6,62.48) 101.6,68.83 102.11,69.34 102.11,80.26 100.33,82.04 97.46,82.04 96.95,81.53 96.95,80.68 ; J12.85 82.8,77.47 82.55,77.22 82.55,62.48 v1(82.17,62.1)
SJ3_POT3: length 24.9
  TOP w0.127: v1(96.77,69.34) v1(92.46,69.34) ; J12.136 89.92,80.85 90.17,80.59 90.17,80.52 93.47,80.52 93.73,80.77 94.61,80.77 94.87,80.52 94.87,80.01 94.49,79.63 94.23,79.63 93.6,78.99 v1(92.2,78.99)
  BOTTOM w0.127: 96.77,69.98 v1(96.77,69.34) ; v1(92.2,78.99) 92.46,78.74 v1(92.46,69.34)
SJ3_POT4: length 26.3
  TOP w0.127: J12.34 79.25,74.93 79.38,74.93 79.5,74.8 91.06,74.8 v1(91.44,75.18)
  BOTTOM w0.127: 92.68,84.03 92.68,84.61 92.2,85.09 91.06,85.09 90.68,84.71 90.68,82.04 91.44,81.28 v1(91.44,75.18)
SJ3_POT5: length 25.3
  TOP w0.127: v1(95.76,74.42) 84.71,74.42 J12.87
  BOTTOM w0.127: U5.12 98.45,80.64 100.58,80.64 101.09,80.14 101.09,77.98 99.82,76.71 99.82,75.82 99.31,75.31 96.27,75.31 95.76,74.8 v1(95.76,74.42)
SJ3_POT6: length 9.8
  TOP w0.127: v1(96.77,74.8) 96.52,74.8 96.01,75.31 92.61,75.31 92.15,75.77 J12.138
  BOTTOM w0.127: v1(96.77,74.8) 96.8,74.78 96.8,73.51
SJ3_POT11: length 31.3
  TOP w0.127: v1(91.19,73.41) 90.93,73.41 89.53,72.01 79.76,72.01 79.25,71.5 J12.36
  BOTTOM w0.127: U2.12 94.18,85.47 93.93,85.72 91.19,85.72 90.42,84.96 90.42,81.91 90.93,81.41 90.93,73.66 v1(91.19,73.41)
SJ3_POT12: length 12.9
  TOP w0.127: v1(98.68,74.55) 98.55,74.55 98.3,74.3 97.79,74.3 94.49,70.99 94.49,70.94 94.23,70.69 J12.140
  BOTTOM w0.127: v1(98.68,74.55) 98.3,74.17 U7.12
SJ3_POT13: length 74
  BOTTOM w0.127: J12.24 75.87,21.16 75.06,21.97 75.06,35.51 J12.18 76.71,37.16 76.71,37.21 77.72,37.21 77.85,37.34 87.25,37.34 87.76,37.85 87.76,53.97 91.95,58.17 91.95,78.36 91.69,78.61 91.69,79.25 92.48,80.04 92.68,80.24 92.68,81.13
SJ3_POT14: length 79.4
  TOP w0.127: J12.50 79.25,21.97 79.63,22.35 95.25,22.35 95.76,22.86 96.27,22.86 96.52,23.11 v1(96.52,23.24) ; v1(93.85,73.28) 96.27,73.28 97.28,74.3 97.28,75.56 98.68,76.96 v1(98.68,77.09)
  BOTTOM w0.127: U5.1 98.45,76.96 98.55,76.96 v1(98.68,77.09) ; v1(93.85,73.28) 93.47,72.9 93.47,61.09 94.39,60.17 94.39,47.5 94.89,46.99 96.01,46.99 96.52,46.48 v1(96.52,23.24)
SJ3_POT15: length 72.5
  TOP w0.127: v1(95,73.91) v1(92.96,73.91) ; J12.76 81.79,21.97 81.79,22.05 94.72,22.05 94.95,21.82 96.06,21.82 96.16,21.92 v1(96.16,22.33)
  BOTTOM w0.127: v1(96.16,22.33) 96.16,22.2 94.79,23.57 93.75,23.57 93.62,23.7 93.62,46.1 93.75,46.23 93.75,46.86 93.88,46.99 93.88,59.54 92.96,60.45 v1(92.96,73.91) ; 95.25,74.17 v1(95,73.91)
SJ3_POT16: length 76.4
  BOTTOM w0.127: J12.102 82.8,20.32 82.68,20.19 82.68,15.62 83.19,15.11 96.52,15.11 97.03,15.62 97.03,25.15 98.42,26.54 98.42,69.09 98.55,69.22 98.55,69.72 98.3,69.98 U7.1
SJ3_POTF1: length 8.4
  BOTTOM w0.127: U15.9 146.79,71.3 146.89,71.2 146.89,71.17 147.14,70.92 147.14,68.88 147.57,68.45 149.5,68.45 149.81,68.15 C61.1 R58.2
SJ3_POTF2: length 7.6
  BOTTOM w0.127: R46.2 C54.1 149.81,69.62 149.58,69.85 147.55,69.85 147.4,70 147.4,71.17 147.27,71.3 146.76,71.8 U15.8
SJ3_POTF3: length 6.5
  BOTTOM w0.127: R39.2 C47.1 149.81,70.97 149.56,71.22 147.73,71.22 146.63,72.31 146.63,72.3 U15.7
SJ3_POTF4: length 6.1
  BOTTOM w0.127: R38.2 C38.1 149.81,72.24 149.45,72.59 148.46,72.59 148.34,72.72 147.32,72.72 147.32,72.8 U15.6
SJ3_POTF5: length 6.3
  BOTTOM w0.127: U15.5 145.67,73.3 146.41,73.3 147.04,73.94 149.53,73.94 149.81,73.66 C37.1 R30.2
SJ3_POTF6: length 7.1
  BOTTOM w0.127: R21.2 C28.1 149.81,75.03 149.53,75.31 147.19,75.31 146.76,74.88 146.76,74.09 146.47,73.8 U15.4
SJ3_POTF7: length 7.9
  BOTTOM w0.127: R12.2 C16.1 149.81,76.25 149.48,76.58 146.94,76.58 146.43,76.07 146.43,74.3 U15.3
SJ3_POTF8: length 8.2
  BOTTOM w0.127: U15.2 145.67,76.71 146.91,77.95 149.22,77.95 C11.1 R8.2
SJ3_POTF9: length 6.8
  BOTTOM w0.127: U15.23 142.19,74.8 142.19,74.93 140.46,76.66 138.1,76.66 138.07,76.63 C17.1 R13.2
SJ3_POTF10: length 6.5
  BOTTOM w0.127: U15.22 141.6,74.3 140.46,75.44 138.3,75.44 138.07,75.21 C29.1 R22.2
SJ3_POTF11: length 5.8
  BOTTOM w0.127: R31.2 C39.1 138.81,74.04 139.32,74.04 139.32,74.07 140.26,74.07 140.51,73.8 U15.21
SJ3_POTF12: length 2.4
  BOTTOM w0.127: 138.81,72.77 C40.1 R48.2
SJ3_PRESENTN: length 128.1
  TOP w0.127: v1(66.29,138.43) 66.42,138.43 67.18,137.67 83.95,137.67 85.09,138.81 89.79,138.81 v1(89.92,138.68) ; v1(102.36,67.82) 99.31,67.82 99.31,67.77 98.93,68.15 J12.141 ; v1(101.35,86.23) 101.6,86.49 102.49,86.49 102.87,86.87 102.87,90.68 99.57,93.98 99.57,96.52 100.2,97.16 101.85,97.16 102.87,98.17 102.87,99.06 102.36,99.57 v1(101.6,99.57)
  BOTTOM w0.127: v1(102.36,67.82) 102.36,80.9 101.35,81.91 v1(101.35,86.23) ; v1(66.29,138.43) 66.59,138.09 J16.45 ; v1(101.6,99.57) 101.6,122.81 102.49,123.7 102.49,126.62 101.6,127.51 101.6,132.59 100.71,133.48 93.6,133.48 90.55,136.53 90.55,137.41 89.92,138.05 v1(89.92,138.68)
SJ3_REL: length 85.1
  TOP w0.127: v1(115.06,100.08) 108.2,100.08 107.82,100.46 106.68,100.46 106.55,100.33 99.06,100.33 98.55,99.82 82.55,99.82 v1(82.04,99.31)
  BOTTOM w0.127: J12.62 81.79,71.5 82.04,71.75 82.04,83.95 82.3,84.2 82.3,95.88 81.91,96.27 81.91,99.19 v1(82.04,99.31) ; v1(115.06,100.08) 117.35,100.08 117.86,100.58 117.86,109.47 122.48,114.09 U27.5 125.27,114.09 125.35,114.17 R78.2
SJ3_RELN: length 98
  TOP w0.127: v1(105.16,125.48) 99.06,125.48 97.79,124.21 85.22,124.21 v1(85.09,124.08)
  BOTTOM w0.127: v1(105.16,125.48) 105.41,125.22 105.41,124.46 105.66,124.21 105.69,124.21 R77.2 105.69,123.44 ; J12.65 79.76,64.39 75.31,64.39 74.55,65.15 74.55,84.33 74.93,84.71 81.79,84.71 82.04,84.96 82.04,95.63 81.53,96.14 81.53,99.95 85.09,103.5 v1(85.09,124.08)
SJ3_SPARE1: length 83.3
  TOP w0.127: v1(133.1,49.66) 126.75,49.66 126.37,49.28 114.81,49.28 114.05,50.04 113.41,50.04 112.65,49.28 84.07,49.28 83.57,48.77 J12.92
  BOTTOM w0.127: v1(133.1,49.66) 132.97,49.66 132.97,62.86 132.72,63.12 132.72,68.45 134.11,69.85 135.89,69.85 R62.2 C120.1 138.07,71.07 138.33,71.32 140.03,71.32 141.48,72.77 142.14,72.77 U15.19
SJ3_SPARE2: length 81.4
  TOP w0.127: J12.118 86.87,47.37 86.87,48.39 87.38,48.89 126.75,48.89 127,49.15 133.48,49.15 v1(134.24,49.91)
  BOTTOM w0.127: 137.92,69.29 C119.1 138.56,69.29 138.56,69.6 138.94,69.98 139.95,69.98 140.72,70.74 140.72,71.5 141.52,72.3 U15.18 ; 137.92,69.29 138.07,69.14 R63.2 ; 137.92,69.29 137.92,69.85 136.4,69.85 136.27,69.72 136.27,69.09 136.02,68.83 135.13,68.83 133.86,67.56 133.86,50.29 v1(134.24,49.91)
SJ4_BRAKE_PWR: length 130.1
  TOP w0.508: J14.3 106.81,89.53 ; 106.81,89.53 J14.2 107.49,90.93 108.61,92.05 110.03,92.05 111.15,90.93 J14.54 ; 106.81,89.53 110.11,89.53 111.25,88.39 J14.55 ; v1(150.37,96.77) v1(129.54,96.77) 123.32,96.77 122.81,96.27 122.81,92.25 122.71,92.15 v1(121.01,92.15)
  BOTTOM w0.508: J14.55 113.06,89.56 116.97,89.56 ; 129.79,98.68 129.54,98.43 v1(129.54,96.77) ; 129.79,98.68 129.84,98.68 129.84,98.73 ; 129.79,98.68 129.84,98.73 ; 129.84,98.73 R64.1 ; 116.97,89.69 120.98,89.69 121.01,89.71 C94.1 ; 116.97,89.69 116.97,89.56 ; 116.97,89.69 J14.106 118.21,92.18 120.98,92.18 v1(121.01,92.15) C110.1 ; C77.1 103.12,88.34 103.25,88.47 103.25,88.52 103.76,89.03 106.81,89.03 J14.3 ; 116.97,89.56 116.97,88.84 ; C66.1 J14.2 ; v1(150.37,96.77) 150.37,127.89 151.26,128.78 151.36,128.78 J13.4 ; J14.54 110.74,92.08 108.71,92.08 108.2,92.58 108.2,94.36 107.7,94.87 C88.1 ; 116.97,88.84 J14.107 ; 116.97,88.84 117.41,88.84 118.97,87.27 120.22,87.27 120.29,87.2 121.11,87.2 121.18,87.12 C112.1
SJ4_BRAKE_RTN: length 122
  TOP w0.508: 119.51,89.53 116.33,89.53 115.82,89.03 115.82,88.06 115.32,87.55 115.27,87.55 J14.81 J14.80 ; 119.51,89.53 J14.132 119.51,91.69 122.17,94.36 v1(122.17,97.41) 122.3,97.54 163.32,97.54 163.83,98.04 J17.1 ; 119.51,89.53 J14.133
  BOTTOM w0.508: 109.35,89.79 109.3,89.74 103.25,89.74 103.25,89.71 C68.1 ; 109.35,89.79 J14.29 110.62,87.12 113.28,87.12 114.49,88.33 ; 109.35,89.79 J14.28 108.58,90.93 107.42,92.1 102.79,92.1 102.74,92.15 C69.1 ; C115.1 119.56,88.34 J14.133 ; C103.1 118.62,98.04 121.67,98.04 122.17,97.54 v1(122.17,97.41) ; 114.49,88.33 J14.81 ; 114.49,88.33 115.44,87.38 115.62,87.38 115.87,87.12 115.87,87.07 117.22,87.07 117.35,86.94 117.45,86.94 118.26,86.13 118.26,84.81 118.14,84.81 118.24,84.71 121.67,84.71 121.67,84.66 121.79,84.53 C109.1 ; J14.132 C114.1
SJ4_BRK_REL: length 37
  TOP w0.127: v1(98.3,131.7) 98.3,131.95 97.92,132.33 95.76,132.33 95.5,132.08 93.98,132.08 v1(93.47,132.59)
  BOTTOM w0.127: J16.52 72.19,136.71 76.45,140.97 88.39,140.97 89.28,140.08 89.28,137.41 93.47,133.22 v1(93.47,132.59) ; v1(98.3,131.7) 98.25,131.66 U19.12
SJ4_GND_SENSEN: length 85.6
  BOTTOM w0.127: U19.13 98.92,130.92 99.06,131.06 100.43,131.06 100.71,130.81 100.71,129.29 100.58,129.16 100.58,102.11 100.33,101.85 100.33,101.09 100.84,100.58 100.84,98.55 101.85,97.54 101.85,95.25 101.92,95.25 101.92,94.49 102.04,94.36 107.19,94.36 107.7,93.85 107.7,93.09 107.19,92.58 102.87,92.58 102.74,92.71 102.04,92.71 101.92,92.58 101.92,87.88 102.04,87.76 103.5,87.76 104.27,88.52 105.03,88.52 106.17,87.38 107.44,87.38 107.95,86.87 107.95,85.09 108.46,84.58 110.49,84.58 111,84.07 111,68.96 J14.63
SJ4_LIFT_MOTOR+: length 134.8
  TOP w1.27: 156.21,45.59 156.21,46.1 156.72,46.61 156.59,46.61 156.21,46.99 C146.1 ; 156.21,45.59 L5.2 ; 156.21,45.59 157.1,46.48 v1(164.59,46.48) L2.2 ; J14.1 108.33,95 110.36,95 110.74,94.62 111.38,94.62 111.89,95.12 ; 115.32,95.12 111.89,95.12 ; 115.32,95.12 J14.105 ; 115.32,95.12 117.09,96.9 117.09,98.17 117.6,98.68 v1(160.4,98.68) ; 111.89,95.12 J14.53
  BOTTOM w0.762: J14.1 106.76,93.52 C70.1
  BOTTOM w1.27: v1(164.59,46.48) 164.59,59.44 164.08,59.94 163.83,59.94 160.4,63.37 v1(160.4,98.68)
SJ4_LIFT_MOTOR-: length 122.5
  TOP w1.27: 142.19,46.3 142.29,46.41 146.02,46.41 146.43,46.81 150.42,46.81 ; 142.19,46.3 L7.2 ; 142.19,46.3 141.86,45.97 141.22,45.97 140.97,45.72 138.18,45.72 135.89,48.01 v1(104.65,48.01) ; 150.42,46.81 L6.2 ; 150.42,46.81 150.47,46.86 C159.1 ; v1(109.22,96.52) 109.09,96.39 107.31,96.39 104.65,93.73 v1(104.65,87.63)
  BOTTOM w0.762: 109.35,96.65 109.35,97.26 C74.1 109.27,96.65 109.35,96.65 ; 109.35,96.65 109.35,94.74 ; 109.35,94.74 109.86,95.25 ; 109.35,94.74 J14.27
  BOTTOM w1.27: 114.43,95 J14.79 ; 114.43,95 114.17,95.25 109.86,95.25 ; 114.43,95 117.98,95 J14.131 ; v1(104.65,48.01) 105.28,48.64 105.28,78.49 104.65,79.12 v1(104.65,87.63) ; 109.35,96.65 v1(109.22,96.52)
SJ4_LM_DOWN: length 34.9
  TOP w0.127: J16.10 65.18,132.17 65.91,131.44 71.12,131.44 71.37,131.19 87.76,131.19 v1(88.27,131.7) ; v1(95.25,130.43) 95,130.18 88.52,130.18 88.27,129.92 v1(88.27,129.54)
  BOTTOM w0.127: v1(95.25,130.43) 95.76,129.92 U19.8 ; v1(88.27,131.7) v1(88.27,129.54)
SJ4_LM_DOWN_A: length 160.8
  TOP w0.127: v1(155.96,112.27) 155.7,112.01 128.52,112.01 128.02,112.52 120.14,112.52 119.63,113.03 v1(119.63,113.54) ; v1(123.19,57.53) 131.95,57.53 135.64,53.85 140.46,53.85 140.72,54.1 149.35,54.1 149.86,54.61 149.86,57.15 150.37,57.66 156.72,57.66 156.97,57.91 v1(156.97,58.42)
  BOTTOM w0.127: v1(155.96,112.27) 156.21,112.01 156.21,101.85 156.46,101.6 156.46,101.09 156.21,100.84 156.21,75.69 156.46,75.44 156.46,64.26 156.21,64.01 156.21,59.94 156.97,59.18 v1(156.97,58.42) ; v1(123.19,57.53) 123.19,37.08 123.06,36.96 122.99,36.96 C127.1 122.1,36.37 122.05,36.32 J14.148 ; v1(119.63,113.54) 119.38,113.54 118.87,114.05 118.87,114.49 118.62,114.74 U27.11 117.81,114.78 R93.2
