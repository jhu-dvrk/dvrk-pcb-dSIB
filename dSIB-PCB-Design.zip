# Allegro board DSIB_REV3_1.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
R0402_R65
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R66
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R67
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R68
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R69
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R70
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R71
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R72
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R73
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R74
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R75
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R76
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R77
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R78
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R79
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R80
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R82
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R83
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R84
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R85
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R86
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R88
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R89
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R92
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R93
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R104
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R118
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R120
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R121
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R122
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_R123
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
R0402_REV1
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R87
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R90
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R91
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R94
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R95
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R96
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R97
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R99
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R100
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R101
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R103
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R105
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R106
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R107
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R108
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R109
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R110
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R111
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R112
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R113
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R115
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC1005_IS0402N_R116
  rect 0.559x0.559 smd: 1(0,0) 2(1.067,0)
RESC3216_IS1206N
  rect 1.524x1.524 smd: 1(0,0) 2(3.302,0)
RESC3225_IS1210N
  rect 1.626x2.54 smd: 1(0,0) 2(3.429,0)
S1210
  rect 1.626x2.54 smd: 1(0,0) 2(3.429,0)
SMSOT23123
  rect 0.864x1.27 smd: 1(0,0)
  rect 0.864x1.016 smd: 2(1.9,0) 3(0.95,1.999)
SO8
  rect 0.61x2.184 smd: 1(0,0)
  oval 0.61x2.184 smd: 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.239) 6(2.54,7.239) 7(1.27,7.239) 8(0,7.239)
TB3508J15
  rect 2.54x2.54 hole 1.524: 1(-5.08,0)
  round 2.54 hole 1.524: 2(0,0) 3(5.08,0)
TSOP65P490_8_D300N_U23
  rect 0.406x1.001 smd: 1(0,0)
  oval 0.406x1.001 smd: 2(0.635,0) 3(1.27,0) 4(1.905,0) 5(1.91,4.341) 6(1.27,4.341) 7(0.64,4.341) 8(0,4.341)
TSOP65P490_8_D300N_U25
  rect 0.406x1.001 smd: 1(0,0)
  oval 0.406x1.001 smd: 2(0.635,0) 3(1.27,0) 4(1.905,0) 5(1.91,4.341) 6(1.27,4.341) 7(0.64,4.341) 8(0,4.341)
TSSOP14
  rect 0.399x1.499 smd: 1(0,0)
  oval 0.399x1.499 smd: 2(0.65,0) 3(1.298,0) 4(1.948,0) 5(2.598,0) 6(3.246,0) 7(3.896,0) 8(3.896,5.895) 9(3.246,5.895) 10(2.598,5.895) 11(1.948,5.895) 12(1.298,5.895) 13(0.65,5.895) 14(0,5.895)
TSSOP16
  rect 0.399x1.499 smd: 1(0,0)
  oval 0.399x1.499 smd: 2(0.65,0) 3(1.298,0) 4(1.948,0) 5(2.598,0) 6(3.246,0) 7(3.896,0) 8(4.549,0) 9(4.549,5.895) 10(3.899,5.895) 11(3.251,5.895) 12(2.601,5.895) 13(1.951,5.895) 14(1.3,5.895) 15(0.65,5.895) 16(0,5.895)
VHDCI68RAM_FIXED2
  rect 0.965x0.965 hole 0.701: 1(0,0)
  round 0.965 hole 0.701: 2(0.8,1.151) 3(1.6,0) 4(2.4,1.151) 5(3.2,0) 6(4,1.151) 7(4.801,0) 8(5.601,1.151) 9(6.401,0) 10(7.201,1.151) 11(8.001,0) 12(8.801,1.151) 13(9.601,0) 14(10.401,1.151) 15(11.201,0) 16(11.999,1.151) 17(12.799,0) 18(13.599,1.151) 19(14.399,0) 20(15.199,1.151) 21(15.999,0) 22(16.8,1.151) 23(17.6,0) 24(18.4,1.151) 25(19.2,0) 26(20,1.151) 27(20.8,0) 28(21.6,1.151) 29(22.4,0) 30(23.2,1.151) 31(24,0) 32(24.801,1.151) 33(25.601,0) 34(26.401,1.151) 35(0.401,-2.349) 36(1.199,-1.199) 37(1.999,-2.349) 38(2.799,-1.199) 39(3.599,-2.349) 40(4.399,-1.199) 41(5.199,-2.349) 42(5.999,-1.199) 43(6.8,-2.349) 44(7.6,-1.199) 45(8.4,-2.349) 46(9.2,-1.199) 47(10,-2.349) 48(10.8,-1.199) 49(11.6,-2.349) 50(12.4,-1.199) 51(13.2,-2.349) 52(14,-1.199) 53(14.801,-2.349) 54(15.601,-1.199) 55(16.401,-2.349) 56(17.201,-1.199) 57(18.001,-2.349) 58(18.801,-1.199) 59(19.601,-2.349) 60(20.401,-1.199) 61(21.201,-2.349) 62(21.999,-1.199) 63(22.799,-2.349) 64(23.599,-1.199) 65(24.399,-2.349) 66(25.199,-1.199) 67(25.999,-2.349) 68(26.8,-1.199)
  round 2.794 hole 1.75: 69(29.576,-1.151) 70(-2.799,-1.151)
  round 2.794 hole 1.199: 71(-7.549,-3.8) 72(34.351,-3.8)
VIA1
  round 0.61 hole 0.254: FV(0,0)
VIA2
  round 0.914 hole 0.406: FV(0,0)

## Nets
GND: C9.2(TP-2) C10.2(TP-2) C11.2(TP-2) C12.2(TP-2) C13.2(TP-2) C14.2(TP-2) C15.2(TP-2) C16.2(TP-2) C17.2(TP-2) C18.2(TP-2) C19.2(TP-2) C20.2(TP-2) C21.2(TP-2) C22.2(TP-2) C23.2(TP-2) C24.2(TP-2) C25.2(TP-2) C26.2(TP-2) C27.2(TP-2) C28.2(TP-2) C29.2(TP-2) C30.2(TP-2) C31.2(TP-2) C32.2(TP-2) C33.2(TP-2) C34.2(TP-2) C35.2(TP-2) C36.2(TP-2) C37.2(TP-2) C38.2(TP-2) C39.2(TP-2) C40.2(TP-2) C41.2(TP-2) C42.2(TP-2) C43.2(TP-2) C44.2(TP-2) C45.2(TP-2) C46.2(TP-2) C47.2(TP-2) C48.2(TP-2) C49.2(TP-2) C50.2(TP-2) C51.2(TP-2) C52.2(TP-2) C54.2(TP-2) C56.2(TP-2) C57.2(TP-2) C59.2(TP-2) C60.2(TP-2) C61.2(TP-2) C62.2(TP-2) C63.2(TP-2) C64.2(TP-2) C116.2(TP-2) C117.2(TP-2) C118.2(TP-2) C119.2(TP-2) C120.2(TP-2) C121.2(TP-2) C122.2(TP-2) C123.2(TP-2) C124.2(TP-2) C125.2(TP-2) C126.2(TP-2) C127.2(TP-2) C128.2(TP-2) C129.1 C130.2(TP-2) C131.2(TP-2) C132.2(TP-2) C133.2(TP-2) C134.2(TP-2) C135.2(TP-2) C151.2(TP-2) C153.2(TP-2) C156.2(TP-2) C157.2(TP-2) C160.2(TP-2) C161.2(TP-2) C174.2(TP-2) C175.2(TP-2) C176.2(TP-2) C177.2(TP-2) C178.2(TP-2) C179.2(TP-2) C180.2(TP-2) C181.2(TP-2) C182.2(TP-2) C183.2(TP-2) C184.2(TP-2) C185.2(TP-2) FV5.FV FV9.FV J9.5 J9.6 J9.7 J9.8 J9.9 J9.10 J9.11 J9.12 J9.25 J9.26 J9.40 J9.42 J9.51 J9.52 J9.58 J9.59 J9.60 J9.61 J9.64 J9.66 J9.77 J9.78 J9.103 J9.104 J9.109 J9.110 J9.111 J9.112 J9.113 J9.114 J9.142 J9.146 J9.147 J9.151 J9.152 J9.157 J9.158 J9.159 J9.160 J10.5 J10.6 J10.7 J10.8 J10.9 J10.10 J10.11 J10.12 J10.25 J10.26 J10.40 J10.42 J10.51 J10.52 J10.58 J10.59 J10.60 J10.61 J10.64 J10.66 J10.77 J10.78 J10.103 J10.104 J10.109 J10.110 J10.111 J10.112 J10.113 J10.114 J10.142 J10.146 J10.147 J10.151 J10.152 J10.157 J10.158 J10.159 J10.160 J12.5 J12.6 J12.7 J12.8 J12.9 J12.10 J12.11 J12.12 J12.25 J12.26 J12.40 J12.42 J12.51 J12.52 J12.58 J12.59 J12.60 J12.61 J12.64 J12.66 J12.77 J12.78 J12.103 J12.104 J12.109 J12.110 J12.111 J12.112 J12.113 J12.114 J12.142 J12.146 J12.147 J12.151 J12.152 J12.157 J12.158 J12.159 J12.160 J14.5 J14.6 J14.7 J14.8 J14.9 J14.10 J14.11 J14.12 J14.25 J14.26 J14.40 J14.42 J14.51 J14.52 J14.58 J14.59 J14.60 J14.61 J14.64 J14.66 J14.77 J14.78 J14.103 J14.104 J14.109 J14.110 J14.111 J14.112 J14.113 J14.114 J14.142 J14.146 J14.147 J14.151 J14.152 J14.157 J14.158 J14.159 J14.160 J16.1 J16.3 J16.34 J16.36 J16.38 J16.59 J16.61 J16.62 J16.63 J16.64 J16.65 J16.66 J16.67 J16.68 R5.2(TP-2) R88.2(TP-2) R97.2(TP-2) R99.2(TP-2) R101.2(TP-2) R103.2(TP-2) R105.2(TP-2) R106.2(TP-2) R107.2(TP-2) R111.2(TP-2) U1.11 U2.11 U3.11 U4.11 U5.11 U6.11 U7.11 U8.11 U9.11 U10.11 U11.11 U12.11 U13.12 U13.15 U14.8 U15.12 U15.15 U15.16 U16.12 U16.15 U16.16 U17.12 U17.15 U17.16 U18.7 U19.7 U20.7 U22.7 U23.4 U23.5 U25.4 U27.7 U27.13 U28.2 U28.7 XPH1.1(TP-1) XPH2.1(TP-1) XPH3.1(TP-1) XPH4.1(TP-1) XPH5.1(TP-1) XPH6.1(TP-1) XPH8.1(TP-1) XPH9.1(TP-1) XPH10.1(TP-1)
GND_AB: C140.1 D2.1 R114.2(TP-2) R115.1 R117.1 U26.31 U26.32
GND_CD: C137.1 D1.1 R96.1 R98.1 R102.2(TP-2) U26.23 U26.24
GND_POWER: C2.2(TP-2) C3.2(TP-2) C4.2(TP-2) C5.2(TP-2) C7.2(TP-2) C8.2(TP-2) C53.2(TP-2) C55.2(TP-2) C58.2(TP-2) C65.2(TP-2) C66.2(TP-2) C67.2(TP-2) C68.2(TP-2) C69.2(TP-2) C70.2(TP-2) C71.2(TP-2) C72.2(TP-2) C73.2(TP-2) C74.2(TP-2) C75.2(TP-2) C76.2(TP-2) C77.2(TP-2) C78.2(TP-2) C79.2(TP-2) C80.2(TP-2) C81.2(TP-2) C82.2(TP-2) C83.2(TP-2) C84.2(TP-2) C85.2(TP-2) C86.2(TP-2) C87.2(TP-2) C88.2(TP-2) C89.2(TP-2) C90.2(TP-2) C91.2(TP-2) C92.2(TP-2) C93.2(TP-2) C94.2(TP-2) C95.2(TP-2) C96.2(TP-2) C97.2(TP-2) C98.2(TP-2) C99.2(TP-2) C100.2(TP-2) C101.2(TP-2) C102.2(TP-2) C103.2(TP-2) C104.2(TP-2) C105.2(TP-2) C106.2(TP-2) C107.2(TP-2) C108.2(TP-2) C109.2(TP-2) C110.2(TP-2) C111.2(TP-2) C112.2(TP-2) C113.2(TP-2) C114.2(TP-2) C115.2(TP-2) C137.2(TP-2) C139.2(TP-2) C140.2(TP-2) C141.2(TP-2) C142.2(TP-2) C143.2(TP-2) C144.2(TP-2) C145.2(TP-2) C150.2(TP-2) C154.2(TP-2) C158.2(TP-2) C162.2(TP-2) D1.2(TP-2) D2.2(TP-2) D3.1 FV6.FV FV7.FV FV8.FV HS1.1 HS1.2 HS1.3 HS1.4(TP-4) J13.5 J13.10 J13.11 J15.1 J15.2 J17.3(TP-3) J18.3(TP-3) J19.3(TP-3) J20.3(TP-3) R5.1 R47.2(TP-2) R51.2(TP-2) R57.2(TP-2) R61.2(TP-2) R95.1 R98.2(TP-2) R104.1 R116.1 R117.2(TP-2) R118.2(TP-2) U24.1 U24.2 U24.3 U24.5 U24.6 U26.8
P3.3V: C116.1 C161.1 U18.14(TP-14) U28.4 U28.5
P5VA: C117.1 C118.1 C131.1 C132.1 C135.1 C157.1 L1.2(TP-2) U23.8(TP-8) U25.8(TP-8)
P12V: C141.1 C142.1 C143.1 C144.1 C150.1 C154.1 L3.2(TP-2) R91.1 U26.1 U26.17 U26.18 U26.19 U26.36(TP-36)
P48V: C2.1 C3.1 C4.1 C5.1 C7.1 C8.1 C139.1 C158.1 C162.1 FV1.FV J15.3 U24.7 U26.21 U26.26 U26.29 U26.34
VCC: C14.1 C20.1 C23.1 C27.1 C62.1 C133.1 C160.1 C174.1 C175.1 C176.1 C177.1 C178.1 C179.1 C180.1 C181.1 C182.1 C183.1 C184.1 C185.1 FV2.FV FV3.FV FV10.FV J16.23 J16.25 J16.27 J16.29 L1.1 R44.1 R52.1 R53.1 R55.1 R62.1 R63.1 R68.1 R69.1 R70.1 R71.1 R72.1 R73.1 R74.1 R75.1 R76.1 R77.1 R78.1 R79.1 R80.1 R81.1 R82.1 R83.1 R84.1 R85.1 R86.1 R89.1 R92.1 R93.1 U1.2 U2.2 U3.2 U4.2 U5.2 U6.2 U7.2 U8.2 U9.2 U10.2 U11.2 U12.2 U13.24 U14.16(TP-16) U15.24 U16.24 U17.24 U19.14 U20.14 U22.14(TP-14) U27.14(TP-14) U28.1 U28.6
A0: J16.39 U13.10 U14.9 U15.10 U16.10 U17.10 U22.1
A0N: J16.5 U22.2
A1: J16.40 U13.11 U14.7 U15.11 U16.11 U17.11 U22.3
A1N: J16.6 U22.4
A2: J16.41 U13.14 U14.6 U15.14 U16.14 U17.14 U22.5
A2N: J16.7 U22.6
A3: J16.42 U13.13 U14.5 U15.13 U16.13 U17.13 U22.9
A3N: J16.8 U22.8
BRAKE1_VMON: R123.2(TP-2) U17.17
BRAKE2_VMON: R122.2(TP-2) U16.17
BRAKE3_VMON: R121.2(TP-2) U15.17
BRAKE4_VMON: R120.2(TP-2) U13.17
BST_A: C155.1 U26.35
BST_B: C149.1 U26.28
BST_C: C147.2(TP-2) U26.27
BST_D: C138.2(TP-2) U26.20
CLK: U14.10 U18.4
DOUTB0: J16.24 R74.2(TP-2) U18.1
DOUTB1: J16.26 R72.2(TP-2) U18.3
DOUTB2: J16.28 R71.2(TP-2) U18.5
DOUTB3: J16.30 R70.2(TP-2) U18.9
FAULT: J16.47 U22.10
FAULTN: J16.13 R110.1 U22.11 U26.3
I_MOT+: C134.1 R90.2(TP-2) U13.19
I_MOT-: C156.1 R113.2(TP-2) U13.18
M1: R103.1 U26.13
M2: R100.1 U26.12
M3: R101.1 U26.11
MOTOR-1: J13.6 J20.2
MOTOR-2: J13.7 J19.2
MOTOR-3: J13.8 J18.2
MOTOR-4: J13.9 J17.2
OTW: J16.48 U22.12
OTWN: J16.14 R112.1 U22.13 U26.2
OUT_A: C155.2(TP-2) L7.1 U26.33
OUT_B: C149.2(TP-2) L6.1 U26.30
OUT_C: C147.1 L5.1 U26.25
OUT_D: C138.1 L2.1 U26.22
PNET24_5: C146.2(TP-2) R102.1
PNET24_6: C159.2(TP-2) R114.1
POT1: J16.35 U17.1
POT2: J16.2 U16.1
POT3: J16.37 U15.1
POT4: J16.4 U13.1
POT-GND-A: J16.57 J16.58 J16.60
POT-VCC: J9.23 J9.31 J9.33 J9.35 J9.49 J9.75 J9.84 J9.86 J9.101 J9.135 J9.137 J9.139 J10.23 J10.31 J10.33 J10.35 J10.49 J10.75 J10.84 J10.86 J10.101 J10.135 J10.137 J10.139 J12.23 J12.31 J12.33 J12.35 J12.49 J12.75 J12.84 J12.86 J12.101 J12.135 J12.137 J12.139 J14.23 J14.31 J14.33 J14.35 J14.49 J14.75 J14.84 J14.86 J14.101 J14.135 J14.137 J14.139 J16.31 J16.32 J16.33
PWM: R111.1 U18.6 U18.11 U26.4
PWMN: R106.1 U18.10 U26.6
RESETN: R91.2(TP-2) R105.1 R107.1 U18.8 U26.5 U26.15
RST: U14.11 U18.2
SJ1_BRAKE_PWR: C87.1 C93.1 C101.1 C102.1 C111.1 C113.1 J10.2 J10.3 J10.54 J10.55 J10.106 J10.107 J13.1 R67.1
SJ1_BRAKE_RTN: C67.1 C75.1 C76.1 C81.1 C86.1 C108.1 J10.28 J10.29 J10.80 J10.81 J10.132 J10.133 J20.1
SJ1_BRK_REL: J16.17 U20.12
SJ1_GND_SENSEN: J10.63 U20.13
SJ1_POT1: J10.32 U6.1
SJ1_POT2: J10.85 U12.9
SJ1_POT3: J10.136 U1.4
SJ1_POT4: J10.34 U6.9
SJ1_POT5: J10.87 U12.12
SJ1_POT6: J10.138 U1.9
SJ1_POT11: J10.36 U6.12
SJ1_POT12: J10.140 U1.12
SJ1_POT13: J10.18 J10.24 U6.4
SJ1_POT14: J10.50 U12.1
SJ1_POT15: J10.76 U12.4
SJ1_POT16: J10.102 U1.1
SJ1_POTF1: C64.1 R60.2(TP-2) U17.9
SJ1_POTF2: C59.1 R54.2(TP-2) U17.8
SJ1_POTF3: C50.1 R42.2(TP-2) U17.7
SJ1_POTF4: C43.1 R35.2(TP-2) U17.6
SJ1_POTF5: C44.1 R34.2(TP-2) U17.5
SJ1_POTF6: C32.1 R25.2(TP-2) U17.4
SJ1_POTF7: C22.1 R17.2(TP-2) U17.3
SJ1_POTF8: C12.1 R9.2(TP-2) U17.2
SJ1_POTF9: C33.1 R27.2(TP-2) U17.23
SJ1_POTF10: C34.1 R26.2(TP-2) U17.22
SJ1_POTF11: C45.1 R36.2(TP-2) U17.21
SJ1_POTF12: C51.1 R43.2(TP-2) U17.20
SJ1_PRESENTN: J10.141 J16.11 R69.2(TP-2)
SJ1_REL: J10.62 R73.2(TP-2) U27.1
SJ1_RELN: J10.65 R81.2(TP-2) U20.2
SJ1_SPARE1: C124.1 J10.92 R44.2(TP-2) U17.19
SJ1_SPARE2: C123.1 J10.118 R55.2(TP-2) U17.18
SJ2_BRAKE_PWR: C72.1 C73.1 C80.1 C99.1 C100.1 C107.1 J9.2 J9.3 J9.54 J9.55 J9.106 J9.107 J13.2 R66.1
SJ2_BRAKE_RTN: C84.1 C85.1 C91.1 C92.1 C98.1 C106.1 J9.28 J9.29 J9.80 J9.81 J9.132 J9.133 J19.1
SJ2_BRK_REL: J16.18 U20.6
SJ2_GND_SENSEN: J9.63 U20.5
SJ2_POT1: J9.32 U4.1
SJ2_POT2: J9.85 U11.9
SJ2_POT3: J9.136 U8.4
SJ2_POT4: J9.34 U4.9
SJ2_POT5: J9.87 U11.12
SJ2_POT6: J9.138 U8.9
SJ2_POT11: J9.36 U4.12
SJ2_POT12: J9.140 U8.12
SJ2_POT13: J9.18 J9.24 U4.4
SJ2_POT14: J9.50 U11.1
SJ2_POT15: J9.76 U11.4
SJ2_POT16: J9.102 U8.1
SJ2_POTF1: C57.1 R50.2(TP-2) U16.9
SJ2_POTF2: C56.1 R49.2(TP-2) U16.8
SJ2_POTF3: C48.1 R40.2(TP-2) U16.7
SJ2_POTF4: C41.1 R32.2(TP-2) U16.6
SJ2_POTF5: C30.1 R23.2(TP-2) U16.5
SJ2_POTF6: C19.1 R15.2(TP-2) U16.4
SJ2_POTF7: C18.1 R14.2(TP-2) U16.3
SJ2_POTF8: C63.1 R59.2(TP-2) U16.2
SJ2_POTF9: C21.1 R16.2(TP-2) U16.23
SJ2_POTF10: C31.1 R24.2(TP-2) U16.22
SJ2_POTF11: C42.1 R33.2(TP-2) U16.21
SJ2_POTF12: C49.1 R41.2(TP-2) U16.20
SJ2_PRESENTN: J9.141 J16.12 R68.2(TP-2)
SJ2_REL: J9.62 R83.2(TP-2) U27.3
SJ2_RELN: J9.65 R84.2(TP-2) U20.4
SJ2_SPARE1: C122.1 J9.92 R52.2(TP-2) U16.19
SJ2_SPARE2: C121.1 J9.118 R53.2(TP-2) U16.18
SJ3_BRAKE_PWR: C79.1 C83.1 C90.1 C95.1 C96.1 C97.1 J12.2 J12.3 J12.54 J12.55 J12.106 J12.107 J13.3 R65.1
SJ3_BRAKE_RTN: C71.1 C78.1 C82.1 C89.1 C104.1 C105.1 J12.28 J12.29 J12.80 J12.81 J12.132 J12.133 J18.1
SJ3_BRK_REL: J16.51 U20.8
SJ3_GND_SENSEN: J12.63 U20.11
SJ3_POT1: J12.32 U2.1
SJ3_POT2: J12.85 U5.9
SJ3_POT3: J12.136 U7.4
SJ3_POT4: J12.34 U2.9
SJ3_POT5: J12.87 U5.12
SJ3_POT6: J12.138 U7.9
SJ3_POT11: J12.36 U2.12
SJ3_POT12: J12.140 U7.12
SJ3_POT13: J12.18 J12.24 U2.4
SJ3_POT14: J12.50 U5.1
SJ3_POT15: J12.76 U5.4
SJ3_POT16: J12.102 U7.1
SJ3_POTF1: C61.1 R58.2(TP-2) U15.9
SJ3_POTF2: C54.1 R46.2(TP-2) U15.8
SJ3_POTF3: C47.1 R39.2(TP-2) U15.7
SJ3_POTF4: C38.1 R38.2(TP-2) U15.6
SJ3_POTF5: C37.1 R30.2(TP-2) U15.5
SJ3_POTF6: C28.1 R21.2(TP-2) U15.4
SJ3_POTF7: C16.1 R12.2(TP-2) U15.3
SJ3_POTF8: C11.1 R8.2(TP-2) U15.2
SJ3_POTF9: C17.1 R13.2(TP-2) U15.23
SJ3_POTF10: C29.1 R22.2(TP-2) U15.22
SJ3_POTF11: C39.1 R31.2(TP-2) U15.21
SJ3_POTF12: C40.1 R48.2(TP-2) U15.20
SJ3_PRESENTN: J12.141 J16.45
SJ3_REL: J12.62 R78.2(TP-2) U27.5
SJ3_RELN: J12.65 R77.2(TP-2) U20.10
SJ3_SPARE1: C120.1 J12.92 R62.2(TP-2) U15.19
SJ3_SPARE2: C119.1 J12.118 R63.2(TP-2) U15.18
SJ4_BRAKE_PWR: C66.1 C77.1 C88.1 C94.1 C110.1 C112.1 J13.4 J14.2 J14.3 J14.54 J14.55 J14.106 J14.107 R64.1
SJ4_BRAKE_RTN: C68.1 C69.1 C103.1 C109.1 C114.1 C115.1 J14.28 J14.29 J14.80 J14.81 J14.132 J14.133 J17.1
SJ4_BRK_REL: J16.52 U19.12
SJ4_GND_SENSEN: J14.63 U19.13
SJ4_LIFT_MOTOR+: C70.1 C146.1 J14.1 J14.53 J14.105 L2.2(TP-2) L5.2(TP-2)
SJ4_LIFT_MOTOR-: C74.1 C159.1 J14.27 J14.79 J14.131 L6.2(TP-2) L7.2(TP-2)
SJ4_LM_DOWN: J16.10 U19.8
SJ4_LM_DOWN_A: C127.1 J14.148 R93.2(TP-2) U27.11
SJ4_LM_DOWN_B: C128.1 J14.149 R82.2(TP-2) U19.10
SJ4_LM_GND_SENSEN: J14.150 R86.2(TP-2) U19.5 U19.11
SJ4_LM_UP: J16.9 U19.6
SJ4_LM_UP_A: J14.144 R79.2(TP-2) U18.13
SJ4_LM_UP_B: J14.145 R92.2(TP-2) U19.4
SJ4_POT1: J14.32 U3.1
SJ4_POT2: J14.85 U9.9
SJ4_POT3: J14.136 U10.4
SJ4_POT4: J14.34 U3.9
SJ4_POT5: J14.87 U9.12
SJ4_POT6: J14.138 U10.9
SJ4_POT11: J14.36 U3.12
SJ4_POT12: J14.140 U10.12
SJ4_POT13: J14.18 J14.24 U3.4
SJ4_POT14: J14.50 U9.1
SJ4_POT15: J14.76 U9.4
SJ4_POT16: J14.102 U10.1
SJ4_POTF1: C60.1 R56.2(TP-2) U13.9
SJ4_POTF2: C52.1 R45.2(TP-2) U13.8
SJ4_POTF3: C46.1 R37.2(TP-2) U13.7
SJ4_POTF4: C35.1 R28.2(TP-2) U13.6
SJ4_POTF5: C25.1 R19.2(TP-2) U13.5
SJ4_POTF6: C24.1 R18.2(TP-2) U13.4
SJ4_POTF7: C13.1 R10.2(TP-2) U13.3
SJ4_POTF8: C9.1 R6.2(TP-2) U13.2
SJ4_POTF9: C10.1 R7.2(TP-2) U13.23
SJ4_POTF10: C15.1 R11.2(TP-2) U13.22
SJ4_POTF11: C26.1 R20.2(TP-2) U13.21
SJ4_POTF12: C36.1 R29.2(TP-2) U13.20
SJ4_PRESENTN: J14.141 J16.46
SJ4_REL: J14.62 R76.2(TP-2) U27.9
SJ4_RELN: J14.65 R75.2(TP-2) U19.2
SJ4_SPARE1: C125.1 J14.92 J16.43 R85.2(TP-2)
SJ4_SPARE2: C126.1 J14.118 J16.44 R80.2(TP-2)
VA_BIAS: C130.1 C153.1 R87.2(TP-2) R108.2(TP-2) U13.16 U23.1 U23.2
VREG: C148.2(TP-2) R100.2(TP-2) R110.2(TP-2) R112.2(TP-2) U26.10
N3819132: C129.2(TP-2) R87.1 R95.2(TP-2) U25.3
N3819136: C136.1 R94.1 R96.2(TP-2) U25.2
N3819148: C136.2(TP-2) R90.1 R94.2(TP-2) U25.1
N3819830: C152.1 R109.1 R115.2(TP-2) U25.6
N3819870: C152.2(TP-2) R109.2(TP-2) R113.1 U25.7
N3819932: C151.1 R108.1 R116.2(TP-2) U25.5
N3820466: C148.1 R118.1 U26.9
N3821182: R97.1 U26.16
N3821198: R99.1 U26.14
N3821898: R104.2(TP-2) U26.7
N3920893: C145.1 L3.1 L4.2(TP-2) U24.4
N4096166: R88.1 R89.2(TP-2) U23.3
N5595023: U23.6 U23.7
N6692939: R17.1 U6.13 U6.14
N6693001: R13.1 U2.5 U2.6
N6693049: R38.1 U2.7 U2.8
N6693089: R12.1 U2.13 U2.14
N6693129: R22.1 U5.15 U5.16
N6693173: R31.1 U5.5 U5.6
N6693213: R41.1 U8.15 U8.16
N6693217: R59.1 U8.13 U8.14
N6693221: R46.1 U5.7 U5.8
N6693293: R30.1 U5.13 U5.14
N6693311: R58.1 U2.15 U2.16
N6693321: R25.1 U1.7 U1.8
N6693393: R48.1 U7.15 U7.16
N6693431: R39.1 U7.5 U7.6
N6693465: R21.1 U7.7 U7.8
N6693509: R8.1 U7.13 U7.14
N6693557: R27.1 U6.5 U6.6
N6693601: R26.1 U12.15 U12.16
N6693683: R35.1 U6.7 U6.8
N6693747: R60.1 U6.15 U6.16
N6693757: R7.1 U3.5 U3.6
N6693797: R28.1 U3.7 U3.8
N6693837: R10.1 U3.13 U3.14
N6693887: R11.1 U9.15 U9.16
N6693927: R20.1 U9.5 U9.6
N6693931: R9.1 U1.13 U1.14
N6693983: R45.1 U9.7 U9.8
N6694061: R19.1 U9.13 U9.14
N6694105: R56.1 U3.15 U3.16
N6694159: R29.1 U10.15 U10.16
N6694205: R37.1 U10.5 U10.6
N6694213: R36.1 U12.5 U12.6
N6694291: R18.1 U10.7 U10.8
N6694359: R6.1 U10.13 U10.14
N6694505: R16.1 U4.5 U4.6
N6694569: R32.1 U4.7 U4.8
N6694609: R14.1 U4.13 U4.14
N6694661: R24.1 U11.15 U11.16
N6694723: R33.1 U11.5 U11.6
N6694749: R49.1 U11.7 U11.8
N6694819: R23.1 U11.13 U11.14
N6694859: R50.1 U4.15 U4.16
N6695135: R40.1 U8.5 U8.6
N6695209: R15.1 U8.7 U8.8
N6695471: R54.1 U12.7 U12.8
N6695607: R34.1 U12.13 U12.14
N6695787: R43.1 U1.15 U1.16
N6695799: R42.1 U1.5 U1.6
N7118838: D3.3 L4.1 U24.8(TP-8)
N7211399: U20.3 U27.4
N7227895: U20.9 U27.6
N7242621: U20.1 U27.2
N7330649: U19.1 U27.8
N7684770: U18.12 U19.3
N7703211: U19.9 U27.10
N7735582: C53.1 R57.1 R67.2(TP-2) R123.1
N7735586: C55.1 R47.1 R66.2(TP-2) R122.1
N7735590: C58.1 R51.1 R65.2(TP-2) R121.1
N7735594: C65.1 R61.1 R64.2(TP-2) R120.1

Pads without a net: D3 2; J9 1 4 13 14 15 16 17 19 20 21 22 27 30 37 38 39 41 43 44 45 46 47 48 53 56 57 67 68 69 70 71 72 73 74 79 82 83 88 89 90 91 93 94 95 96 97 98 99 100 105 108 115 116 117 119 120 121 122 123 124 125 126 127 128 129 130 131 134 143 144 145 148 149 150 153 154 155 156 161 162; J10 1 4 13 14 15 16 17 19 20 21 22 27 30 37 38 39 41 43 44 45 46 47 48 53 56 57 67 68 69 70 71 72 73 74 79 82 83 88 89 90 91 93 94 95 96 97 98 99 100 105 108 115 116 117 119 120 121 122 123 124 125 126 127 128 129 130 131 134 143 144 145 148 149 150 153 154 155 156 161 162; J12 1 4 13 14 15 16 17 19 20 21 22 27 30 37 38 39 41 43 44 45 46 47 48 53 56 57 67 68 69 70 71 72 73 74 79 82 83 88 89 90 91 93 94 95 96 97 98 99 100 105 108 115 116 117 119 120 121 122 123 124 125 126 127 128 129 130 131 134 143 144 145 148 149 150 153 154 155 156 161 162; J14 4 13 14 15 16 17 19 20 21 22 30 37 38 39 41 43 44 45 46 47 48 56 57 67 68 69 70 71 72 73 74 82 83 88 89 90 91 93 94 95 96 97 98 99 100 108 115 116 117 119 120 121 122 123 124 125 126 127 128 129 130 134 143 153 154 155 156 161 162; J16 15 16 19 20 21 22 49 50 53 54 55 56 69 70 71 72; U1 3 10 17; U2 3 10 17; U3 3 10 17; U4 3 10 17; U5 3 10 17; U6 3 10 17; U7 3 10 17; U8 3 10 17; U9 3 10 17; U10 3 10 17; U11 3 10 17; U12 3 10 17; U14 1 2 3 4 12 13 14 15; U27 12; U28 3

## Via types
v1: diameter 0.61, hole 0.254, TOP to BOTTOM, 763 vias
v2: diameter 0.914, hole 0.406, TOP to BOTTOM, 30 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
GND: length 1093
  TOP w0.508: 50,80.3 50.55,79.76 54.53,79.76 J9.110 ; 50,80.3 J9.58 ; 50,80.3 49.45,79.76 46.56,79.76 J9.6 ; J9.158 32.51,4.8 32.51,4.85 J10.160 ; R106.2 v1(151.18,16.1) 150.5,15.42 148.54,15.42 148.44,15.52 R111.2 ; J14.25 J14.51 J14.77 J14.103 ; J9.25 J9.51 J9.77 J9.103 ; 81.03,76.33 J12.60 ; 81.03,76.33 80.39,76.96 77.72,76.96 76.58,75.82 75.95,75.82 J12.8 ; 81.03,76.33 81.03,76.58 81.53,77.09 84.02,77.09 84.71,76.4 86.11,76.4 J12.112 ; J14.6 107.9,81.86 110.79,81.86 J14.58 112.57,80.77 113.69,81.89 115.11,81.89 116.23,80.77 J14.110 ; J10.9 15.87,73.28 17.02,72.14 19.18,72.14 J10.61 21.41,72.19 24.31,72.19 J10.113 ; J14.64 111.15,65.53 110.03,66.65 108.61,66.65 107.49,65.53 J14.12 ; 60.45,104.83 J12.157 ; 60.45,104.83 J9.159 ; 60.45,104.83 60.45,107.7 48.26,107.7 47.75,107.19 47.75,105.33 47.24,104.83 J9.157 ; 155.3,16.26 155.32,16.26 v1(155.3,16.1) 155.3,16.26 ; 155.3,16.26 R101.2 ; J14.26 J14.52 J14.78 J14.104 ; v1(23.37,109.85) 22.99,109.47 21.46,109.47 20.7,108.71 18.03,108.71 17.53,108.2 17.53,105.38 17.02,104.88 J10.157 ; v1(167.18,127.66) 167.18,125.04 167.08,124.94 167.07,124.94 166.99,124.87 U28.7 ; 161.75,17.02 R107.2 ; J12.146 87.63,42.55 87.5,42.67 79.76,42.67 79.63,42.55 79.5,42.55 J12.42 ; v1(147.83,74.47) v1(147.83,73.25) ; J9.160 J12.158 77.72,4.8 78.23,5.31 78.23,7.24 78.74,7.75 85.85,7.75 86.36,7.24 86.36,5.31 86.87,4.8 J12.160 ; J12.64 79.93,66.7 75.95,66.7 J12.12 60.99,65.61 60.81,65.79 60.81,65.74 60.68,65.61 J9.142 ; R105.2 R99.2 R103.2 v1(158.04,16.1) ; J10.12 16.38,64.52 19.18,64.52 J10.64 ; J12.103 J12.77 J12.51 ; XPH4.1 169.37,21.21 168.86,20.7 163.32,20.7 v1(162.31,19.68) R97.2 ; J14.142 123.37,65.53 123.88,66.04 v1(123.88,67.23) ; J9.64 49.45,66.7 45.47,66.7 J9.12 ; 22.86,18.67 4.78,18.67 4.27,19.18 XPH1.1 ; 15.24,16.13 17.78,16.13 ; J14.40 J14.66
  BOTTOM w0.254: U20.7 103.9,120.89 103.5,121.28 v1(103.5,121.41) ; 131.83,82.17 131.83,82.04 130.87,81.08 U3.11 ; U15.16 U15.15 141.8,70.8 v1(141.6,70.99) ; U5.11 97.95,81.5 ; U17.16 20.8,112.36 20.3,111.87 ; v1(34.16,74.17) 34.58,74.58 U12.11 ; U7.11 97.8,74.8 v1(97.79,74.8) ; C31.2 C21.2 ; 140.59,84.46 U13.12 140.59,83.82 141.1,83.31 v1(141.15,83.31) ; 20.3,111.87 20.19,111.87 v1(20.19,111.76) ; 20.3,111.87 21.08,111.87 ; U1.11 21.5,98.52 v1(21.59,98.43) ; U10.11 125.53,81.35 v1(125.48,81.41) ; v1(67.31,81.91) 67.31,81.79 67.47,81.63 U8.11 ; v1(93.6,85.22) 93.6,84.96 93.68,84.88 U2.11 ; U19.7 95.9,129.42 v1(95.5,129.03) ; U9.11 125.69,73.45 124.46,74.68 124.46,75.34 C179.2 ; 64.4,72.14 U11.11 ; 36.99,83.98 U4.11 ; U16.16 53.08,113.93 52.3,113.16 v1(52.2,113.16)
  BOTTOM w0.381: 110.79,126.75 110.52,127.03 110.52,130.02 ; U23.5 150.42,57.09 149.81,57.71 C131.2 ; U22.7 82.26,120.18 v1(82.68,119.76) ; 151.92,57.09 152.04,56.97
  BOTTOM w0.508: v1(23.37,109.85) 23.45,109.85 23.58,109.98 U17.12 23.58,110.87 ; v1(25.91,120.55) 26.16,120.29 26.16,120.17 26.29,120.04 C12.2 ; U18.7 108.21,132.09 108.2,132.08 ; J10.157 13.46,98.55 13.59,98.43 14.6,98.43 14.6,98.4 C183.2 ; 144.15,56.9 144.58,57.33 145.59,57.33 145.92,57.66 v1(146.3,57.66) 146.86,57.66 C135.2 C132.2 C131.2 ; 144.15,56.9 143.81,56.57 C117.2 ; 144.15,56.9 143.64,56.9 142.11,58.42 142.11,66.42 142.49,66.8 v1(144.93,66.8) ; 144.15,56.9 144.27,56.9 144.65,57.28 145.67,57.28 ; 144.67,67.07 144.63,67.11 C62.2 ; 144.67,67.07 U15.12 144.67,69.8 ; 144.67,67.07 v1(144.93,66.8) ; 144.67,67.07 144.67,67.06 v1(144.93,66.8) ; C16.2 147.83,76 v1(147.83,76.07) ; C37.2 v1(147.83,73.25) ; v1(147.83,74.47) 147.83,74.52 147.93,74.63 C28.2 ; v1(128.65,112.65) 129.16,113.16 129.16,137.54 XPH2.1 ; 155.14,47.98 C153.2 155.18,49.36 U25.4 153.11,51.08 153.01,51.18 153.01,52.96 152.73,53.24 152.73,53.57 152.17,54.13 ; 155.14,47.98 C130.2 155.14,47.22 ; 155.14,47.98 151.82,47.98 C151.2 ; 152.17,54.13 C157.2 ; 152.17,54.13 152.4,54.36 152.4,55.91 152.91,56.41 ; J14.158 105.03,14.1 106.81,15.88 J14.26 J14.25 ; J12.104 J12.103 84.58,19.63 84.58,19.81 89.28,19.81 90.04,20.57 90.04,24.84 J12.152 J12.151 89.36,28.78 89.87,29.29 89.87,37.72 J12.147 J12.146 ; C52.2 145.41,84.38 ; 145.41,84.38 145.29,84.51 145.29,84.58 FV9.FV 145.08,84.38 145.41,84.38 ; C29.2 v1(139.9,74.78) ; 152.04,56.97 152.6,56.41 152.91,56.41 ; v1(60.05,117.32) 60.17,117.45 C30.2 ; 111.89,47.88 112.65,48.64 113.49,48.64 113.74,48.89 v1(113.74,49.48) ; 111.89,47.88 J14.66 ; 111.89,47.88 111.89,48.39 112.22,48.72 C125.2 ; C41.2 v1(60.05,116.08) ; v1(145.08,88.75) 145.08,88.62 145.21,88.49 C25.2 ; v1(11.28,73.86) 11.35,73.94 C185.2 ; J12.52 J12.51 ; 75.82,16.13 75.82,16.08 J12.26 ; 75.82,16.13 75.77,16.08 74.68,16.08 74.17,15.57 J12.158 ; 75.82,16.13 75.95,16.26 J12.25 ; J9.160 59.69,4.8 59.69,5.97 53.09,12.57 J9.104 ; v1(66.45,75.69) 66.52,75.77 C180.2 ; C20.2 55.78,120.88 55.91,121.01 55.91,121.79 v1(55.88,121.79) ; XPH3.1 167.26,137.54 167.26,127.74 v1(167.18,127.66) 167.26,127.58 C161.2 ; v1(155.3,16.1) 155.32,16.26 155.19,16.38 155.19,47.12 155.14,47.12 155.14,47.22 ; J12.109 J12.110 J12.111 J12.112 J12.113 J12.114 87.12,69.6 87.12,69.22 87.2,69.22 87.2,67.44 87.58,67.06 87.63,67.06 87.63,66.67 J12.142 ; v1(40.54,124.56) C27.2 ; 160.78,19.18 161.29,19.68 v1(162.31,19.68) ; J9.152 J9.151 ; v1(139.9,73.51) 139.9,73.41 C39.2 ; v1(139.9,76.02) 139.9,76.15 C17.2 ; 82.59,135.32 J16.66 84.19,135.32 ; 82.59,135.32 J16.64 ; 82.59,135.32 J16.65 ; J10.5 15.24,81.71 15.65,81.31 J10.6 J10.7 J10.8 J10.9 J10.10 J10.11 J10.12 ; C129.1 155.85,46.51 155.14,47.22 ; J10.159 29.72,104.9 27.69,104.9 27.18,105.41 27.18,110.24 C64.2 26.16,110.44 FV5.FV 26.06,110.59 ; v1(131.7,82.68) 131.7,82.3 132.21,81.79 C156.2 ; 27.81,41.53 J10.146 ; 22.86,16.13 22.86,10.67 25.65,7.87 25.65,5.36 26.16,4.85 J10.160 ; J9.142 57.15,66.67 57.15,66.8 56.77,67.18 56.77,69.47 56.64,69.6 56.64,69.67 J9.114 J9.113 J9.112 J9.111 J9.110 J9.109 ; v1(25.91,118.95) 25.91,118.77 26.01,118.67 C22.2 C32.2 26.29,117.3 26.16,117.42 26.16,117.55 26.06,117.55 26.06,117.68 v1(26.19,117.81) ; v1(147.83,72.01) 147.95,71.88 C38.2 ; 143.81,52.02 143.76,52.07 C117.2 ; 143.81,52.02 C117.2 ; 143.81,52.02 C118.2 ; J12.12 J12.11 J12.10 J12.9 J12.8 J12.7 J12.6 J12.5 ; J16.1 J16.3 ; 96.77,75.84 96.01,75.84 v1(96.01,75.95) ; 96.77,75.84 C175.2 ; 96.77,75.84 96.77,75.95 96.9,75.95 ; J14.40 109.47,46.48 110.62,45.34 110.62,42.67 J14.42 ; J14.12 J14.11 J14.10 J14.9 106.81,73.28 106.55,73.28 106.55,75.44 106.68,75.44 106.68,75.56 106.81,75.56 J14.8 106.81,75.95 106.55,75.95 106.55,78.11 106.81,78.11 J14.7 106.81,78.36 106.55,78.36 106.55,80.52 106.68,80.52 106.68,80.64 106.81,80.64 J14.6 106.81,81.03 106.55,81.03 106.55,83.19 106.81,83.19 J14.5 ; v1(60.05,114.45) 60.3,114.71 C48.2 ; v1(119.18,116.08) 119.14,116.04 U27.13 ; C34.2 18.67,116.26 v1(18.67,116.97) ; C34.2 C33.2 ; C34.2 18.67,116.15 C45.2 18.67,113.84 C51.2 ; v1(145.08,92.61) C9.2 ; v1(145.08,90.12) 145.16,90.12 145.41,89.87 C24.2 ; J10.58 J10.59 J10.60 J10.61 ; C43.2 v1(26.04,114.55) ; 20.32,46.61 20.32,48.31 20.8,48.79 C124.2 ; v1(26.06,111.84) 26.06,111.81 C59.2 ; 84.19,135.32 J16.68 84.99,132.58 J16.34 ; 84.19,135.32 J16.67 ; C49.2 50.42,114.71 v1(50.42,114.68) ; 124.05,34.65 C127.2 124.05,37.16 v1(124.18,37.29) ; 124.05,34.65 C128.2 ; 124.05,34.65 v1(124.08,34.67) ; C44.2 26.19,115.93 26.06,115.8 v1(26.06,115.7) ; C56.2 v1(60.05,113.33) ; v1(134.72,90.02) C15.2 133.81,88.77 ; v1(27.3,48.77) 27.3,48.79 C123.2 ; 110.79,126.75 C116.2 ; v1(93.73,77.72) C174.2 ; J14.151 J14.152 120.6,26.16 120.6,20.09 120.5,19.99 115.87,19.99 J14.103 ; v1(81.73,134.53) 81.73,134.93 J16.63 80.19,134.87 J16.62 79.39,135.32 J16.61 J16.59 ; 123.6,75.39 v1(123.65,75.39) C179.2 ; J10.158 15.24,4.85 15.24,18.67 ; 118.24,50.5 118.62,50.88 v1(118.9,50.88) ; 118.24,50.5 118.24,48.84 C126.2 ; 118.24,50.5 118.24,64.26 J14.142 118.41,66.62 118.41,69.16 J14.114 J14.113 J14.112 J14.111 J14.110 J14.109 ; 118.24,50.5 118.11,50.37 C126.2 ; C31.2 v1(50.14,117.45) ; C10.2 134.49,91.39 134.62,91.26 v1(134.72,91.26) ; C35.2 v1(145.08,87.12) ; J9.42 49.02,42.55 49.15,42.67 49.15,45.34 49.02,45.47 J9.40 ; C177.2 132.64,76 v1(132.77,76.12) ; J9.159 59.94,101.22 59.56,100.84 55.88,100.84 55.37,101.35 55.37,104.78 55.88,105.28 55.88,111.15 v1(56.08,111.35) 56.15,111.42 U16.12 ; 97.95,81.5 v1(97.92,81.53) ; 50.42,115.85 50.19,116.08 ; 50.42,115.85 v1(50.42,115.82) ; 50.42,115.85 50.42,115.95 50.29,116.08 50.19,116.08 ; 50.19,116.08 C42.2 ; v1(26.06,113.31) 26.19,113.18 C50.2 ; J12.61 J12.60 J12.59 J12.58 ; U14.8 45.59,125.2 45.57,125.22 v1(45.57,125.86) ; J14.58 J14.59 J14.60 J14.61 ; C57.2 v1(60.05,111.96) ; C176.2 v1(99.82,68.53) ; J9.5 J9.6 J9.7 J9.8 J9.9 J9.10 J9.11 J9.12 ; v1(139.9,72.31) 139.9,72.03 C40.2 ; 152.91,56.41 154.31,56.41 154.79,56.9 154.79,56.95 154.94,57.1 U23.4 156.31,57.1 157,56.41 R88.2 157.58,56.34 C133.2 ; C178.2 124.33,67.61 124.33,67.23 v1(123.88,67.23) ; v1(145.08,91.36) 145.21,91.24 C13.2 ; J9.61 J9.60 J9.59 J9.58 ; v1(139.9,70.66) C120.2 ; v1(147.9,70.51) C47.2 ; J9.64 51.56,64.52 51.69,64.39 51.69,49.91 51.94,49.66 51.97,49.66 C122.2 v1(51.05,48.87) 50.55,48.36 J9.66 ; v1(134.62,64.01) 134.62,63.88 134.87,63.63 134.95,63.63 R5.2 134.95,60.33 135,60.33 135.13,60.2 v1(135.13,57.15) ; 108.2,132.08 v1(107.95,132.08) ; 108.2,132.08 108.46,132.08 110.52,130.02 ; U23.5 151.92,57.09 ; C121.2 v1(57.61,48.87) ; v1(147.83,77.24) 147.95,77.24 148.08,77.37 C11.2 ; J10.109 J10.110 J10.111 J10.112 J10.113 J10.114 26.49,69.65 26.49,67.11 J10.142 ; C61.2 148.08,67.77 147.95,67.64 v1(147.95,67.51) ; 133.81,88.77 C26.2 ; 133.81,88.77 134.62,88.77 134.62,88.9 v1(134.85,88.9) ; J14.147 J14.146 118.11,42.8 C126.2 ; J12.42 79.5,42.55 79.63,42.67 79.63,45.34 79.5,45.47 J12.40 ; J12.78 J12.77 ; C14.2 140.37,92.6 140.36,92.61 v1(140.49,92.61) ; v1(39.24,78.49) 39.24,78.41 39.12,78.28 C182.2 38.1,77.6 38.61,77.09 39.75,77.09 40.84,76 C184.2 v1(41.76,74.63) ; C119.2 v1(139.78,69.29) ; J9.147 J9.146 ; C18.2 C19.2 60.17,118.67 v1(60.05,118.8) ; J9.25 J9.26 45.47,4.8 J9.158 ; J10.152 27.94,28.83 ; v1(131.95,86.03) 132.08,85.9 C134.2 ; U27.7 122.55,112.79 122.55,111.12 121.28,109.85 J14.159 ; XPH5.1 9.4,137.54 9.91,137.03 v1(9.91,117.22) ; v1(162.81,93.22) 162.81,110.74 166.24,114.17 166.24,119.38 166.5,119.63 166.57,119.63 C160.2 166.57,121.21 166.99,121.63 U28.2 166.99,123.01 166.98,123.01 166.93,123.06 166.93,123.73 U28.7 ; v1(134.72,87.27) C36.2 ; C46.2 v1(145.14,85.75) ; C23.2 23.47,119.13 23.34,119.25 23.34,119.3 v1(23.22,119.43) ; C60.2 145.24,83.01 144.98,83.26 v1(144.73,83.26) ; C54.2 v1(147.9,69.14) ; v1(72.24,72.19) C181.2 ; C63.2 v1(59.44,121.41) ; v1(37.08,84.07) 36.99,83.98 ; v1(64.39,72.14) 64.4,72.14
  vias: v1(11.43,83.44) v1(137.29,85.34)
GND_AB: length 36.8
  TOP w0.508: U26.31 150.93,36.02 150.28,36.67 ; C140.1 140.5,50.02 D2.1 ; 150.28,36.67 150.28,37.05 149.99,37.34 149.99,37.72 150.11,37.59 ; 150.28,36.67 U26.32
  TOP w0.762: C140.1 141.68,50.09 v1(141.99,49.78)
  TOP w1.27: R114.2 141.99,49.33 v1(141.99,49.78) ; R117.1 147.83,41.25 148.21,40.87 v1(148.21,40.39) 150.11,38.48 150.11,37.59
  BOTTOM w0.254: R115.1 146.89,49.86 146.3,49.28 142.49,49.28 v1(141.99,49.78)
  BOTTOM w1.27: v1(148.21,40.39) 143.76,40.39 143.26,40.89 143.26,48.89 142.88,48.89 142.49,49.28
GND_CD: length 32.5
  TOP w0.508: U26.24 155.48,35.97 156.13,36.62 ; 156.13,36.62 v1(156.46,36.96) ; 156.13,36.62 U26.23 ; 163.45,50.39 C137.1 D1.1
  TOP w1.27: R98.1 160.32,40.51 159.82,40 v1(159.51,40) ; v1(162.05,50.04) 163.09,50.04 163.45,50.39 R102.2
  BOTTOM w1.27: v1(156.46,36.96) v1(159.51,40) 159.51,40.39 162.05,40.39 162.56,40.89 162.56,49.53 v1(162.05,50.04) 161.54,50.04 160.88,50.7 R96.1
GND_POWER: length 688
  TOP w0.381: R104.1 152.22,19.46 ; 152.22,19.46 R118.2 ; 152.22,19.46 U26.8
  TOP w0.762: 82.93,97.92 90.42,97.92 v2(93.09,95.25) ; 82.93,97.92 v2(77.85,97.92) ; 82.93,97.92 v2(82.93,97.41) ; v2(127.76,99.95) 116.46,99.95 115.01,98.55 108.65,98.55 108.58,98.43 108.46,98.55 ; C154.2 143.31,22.25 143.26,22.3 C4.2 C5.2 C2.2 C8.2 143.26,34.04 143.61,34.39 143.56,34.39 C141.2 v2(142.27,35.15) ; 167.08,48.72 C137.2 168.25,50.39 172.67,54.81 HS1.3 ; 167.08,48.72 D1.2 ; 167.08,48.72 166.56,48.19 166.56,43.39 166.07,42.9 163.83,42.9 163.45,43.28 163.17,43.28 161.85,44.6 161.8,44.55 R98.2 ; C7.2 163.98,29.06 163.45,29.59 ; C7.2 C3.2 162.92,26.16 163.58,25.5 163.58,23.16 162.61,22.2 C142.2 ; C7.2 163.45,29.59 ; 163.45,29.59 162.92,30.12 C162.2 C158.2 162.92,34.75 162.76,34.9 162.76,35.03 162.69,35.03 v2(162.69,35.15) C143.2 ; 139.14,48.87 139.14,48.77 139.55,48.36 D2.2 139.14,48.87 ; 139.14,48.87 C140.2 137.97,50.09 v2(137.92,50.04) 135.76,52.2 133.35,52.2 132.84,52.7 132.84,54.69 132.72,54.81 HS1.1 ; R117.2 144.65,44.55 ; 144.65,44.55 144.58,44.55 FV8.FV 144.65,44.55 ; v2(153.03,6.98) 151.89,5.84 133.35,5.84 132.84,5.33 132.84,3.94 132.72,3.81 HS1.2 129.69,6.86 129.57,6.98 128.27,6.98 124.08,11.18 v2(77.22,11.18) ; 140.06,47.55 145.14,47.55 145.24,47.65 v2(145.24,48.44) ; J13.11 161.16,131.06 161.16,130.18 160.66,129.67 J13.5 ; 40.39,93.34 40.39,99.19 41.78,100.58 46.23,100.58 46.99,101.35 v2(49.28,101.35) ; 40.39,93.34 38.73,95 33.4,95 v2(32.51,94.11) 32.51,95.88 30.48,97.92 v2(25.91,97.92) ; 40.39,93.34 v2(40.51,93.22) ; v2(175.64,120.9) J17.3 J18.3 J19.3 J20.3 ; 108.46,98.55 104.39,98.55 101.98,96.14 v2(100.46,96.14) ; 108.46,98.55 v2(108.58,98.55) ; R118.2 152.86,18.34 v2(152.91,18.29) ; FV6.FV 61.59,93.73 v2(72.64,93.73)
  BOTTOM w0.254: 25.3,97.92 C108.2 ; v2(145.24,48.44) 145.31,48.36 R116.1
  BOTTOM w0.508: v2(49.28,101.35) 49.23,101.3 C73.2 C72.2 ; 46.02,110.74 R47.2
  BOTTOM w0.762: v2(82.93,97.41) 82.93,97.49 C78.2 ; 12.27,93.68 12.19,93.6 12.06,93.6 11.56,94.11 11.56,100.97 9.78,102.74 9.78,106.43 12.32,108.97 12.32,110.11 12.19,110.24 12.19,111.51 12.32,111.63 ; 12.27,93.68 12.27,93.93 13.33,95 21.34,95 21.72,95.38 21.72,96.01 23.62,97.92 v2(25.91,97.92) ; 12.27,93.68 C111.2 C87.2 12.27,89.79 ; C150.2 164.74,108.17 165.25,107.66 167.82,107.66 167.83,107.65 ; 101.35,89.79 C66.2 C69.2 C70.2 C88.2 101.17,94.87 100.66,95.38 100.66,96.01 100.53,96.14 v2(100.46,96.14) ; 101.35,89.79 C68.2 ; 101.35,89.79 101.27,89.71 ; C82.2 C104.2 C95.2 ; C82.2 97.74,89.71 98.55,88.9 FV7.FV 100.51,89.71 101.27,89.71 ; C82.2 C89.2 C96.2 92.96,95.12 v2(93.09,95.25) ; R47.2 46.02,112.01 45.85,112.01 ; C106.2 C99.2 C98.2 C91.2 C84.2 C80.2 61.26,93.29 FV6.FV 59.44,95.12 55.88,95.12 53.21,97.79 C72.2 ; 77.98,97.49 77.83,97.49 v2(77.85,97.92) 77.85,97.61 77.98,97.49 ; 77.98,97.49 77.85,97.36 77.85,97.28 74.17,93.6 72.67,93.6 72.54,93.47 ; 77.98,97.49 C79.2 ; 101.27,89.71 C68.2 ; C68.2 C77.2 ; U24.5 175.41,128.19 C139.2 ; U24.5 U24.6 176.68,122.56 176.71,122.56 176.83,122.43 176.83,119.02 176.63,118.82 176.68,118.77 U24.3 U24.2 U24.1 179.22,113.26 C145.2 179.25,113.13 179.25,111.3 177.95,110.01 173.28,110.01 D3.1 173.28,109.09 171.83,107.65 167.83,107.65 ; U24.5 175.41,122.56 175.51,122.56 175.64,122.43 v2(175.64,120.9) ; C74.2 108.2,98.17 v2(108.58,98.55) 112.14,98.55 114.3,96.39 119.51,96.39 119.51,97.28 C103.2 120.52,97.28 122.99,94.82 C110.2 C114.2 C94.2 C115.2 122.99,87.63 123.49,87.12 C112.2 123.49,86.61 123.49,84.53 C109.2 ; 72.54,93.47 72.54,93.62 v2(72.64,93.73) ; 72.54,93.47 C71.2 C83.2 C105.2 C90.2 C97.2 72.54,86.23 72.9,86.23 73.41,85.72 73.41,60.45 74.42,59.44 74.42,20.45 74.93,19.94 76.71,19.94 77.22,19.43 v2(77.22,11.18) ; C75.2 C102.2 C76.2 12.27,86.97 11.81,86.97 11.81,85.09 12.19,84.71 C113.2 ; v2(40.51,93.22) 40.66,92.95 40.69,92.89 C92.2 C100.2 C85.2 C107.2 ; v2(32.51,94.11) 32.51,93.47 32.31,93.27 C101.2 C81.2 C86.2 C67.2 C93.2 ; C58.2 R51.2 137.64,65.18 138.38,64.44 R5.1 138.38,60.2 138.3,60.2 137.92,59.82 v2(137.92,50.04) ; C144.2 167.83,107.65 ; 45.09,110.97 45.09,110.87 45.21,110.74 46.02,110.74 C55.2 46.02,109.6 45.97,109.6 46.61,108.97 47.88,108.97 48.39,108.46 48.39,102.23 v2(49.28,101.35) ; v2(161.29,47.75) 161.29,48.39 160.35,49.33 R95.1 ; v2(127.76,99.95) 127.76,100.58 128.02,100.84 C65.2 R61.2 128.78,109.6 130.56,111.38 130.56,115.57 136.53,121.54 136.53,127 136.14,127.38 136.07,127.38 J13.10 141.02,136.02 156.34,136.02 161.11,131.24 J13.11 161.29,131.06 J18.3
  BOTTOM w2.54: J15.1 J15.2
P3.3V: length 59.3
  TOP w0.127: v1(164.72,124.71) v1(114.05,124.71)
  BOTTOM w0.127: C161.1 166.04,126.67 U28.4 ; U28.4 U28.5 ; U28.4 165.61,125.13 165.61,125.09 165.23,124.71 v1(164.72,124.71) ; v1(114.05,124.71) 113.28,124.71 112.78,125.22 C116.1 112.78,128.17 U18.14
P5VA: length 23
  TOP w0.508: v1(145.08,56.39) 145.08,57.84 145.03,57.89 v1(145.03,58.01)
  BOTTOM w0.381: C131.1 150.24,58.78 150.47,59 U23.8
  BOTTOM w0.508: 150.84,54.28 U25.8 ; 150.84,54.28 149.35,55.75 148.16,55.75 147.57,55.12 145.24,55.12 ; 150.84,54.28 150.84,54.32 C157.1 ; 145.24,55.12 C117.1 C118.1 ; 145.24,55.12 145.16,55.12 ; C131.1 C132.1 C135.1 145.8,58.78 v1(145.03,58.01) ; v1(145.08,56.39) 145.16,56.39 145.16,56.26 145.04,56.26 145.04,55.24 145.16,55.12 ; 145.16,55.12 L1.2
P12V: length 149.7
  TOP w0.381: U26.36 145.74,35.2 C141.1 ; U26.17 U26.18 C142.1
  TOP w0.508: 160.17,35.2 U26.19 ; 160.17,35.2 160.17,36.07 v1(165.86,36.07) ; 160.17,35.2 C143.1 160.17,34.29 160.3,34.16 161.42,34.16 161.8,33.78 161.8,25.15 160.02,23.37 C142.1 ; R91.1 149.81,16.26 v1(149.61,16.26) ; C141.1 144.53,33.91 144.27,33.66 144.27,23.75 144.78,23.24 145.82,23.24 145.95,23.11 ; U26.17 158.07,23.37 157.99,23.37 156.46,24.89 146.56,24.89 146.05,24.38 146.05,23.24 145.95,23.24 145.95,23.11 ; v1(147.57,20.95) 147.68,20.95 U26.1 146,22.2 C154.1 145.95,23.11
  BOTTOM w0.508: v1(149.61,16.26) 148.08,16.26 147.57,16.76 v1(147.57,20.95) ; L3.2 167.83,113.75 C144.1 165.85,111.09 C150.1 163.83,109.98 163.83,101.35 164.97,100.2 164.97,73.53 165.99,72.52 165.99,60.2 165.86,60.07 v1(165.86,36.07)
P48V: length 136.6
  TOP w0.381: 148.98,33.79 U26.34 ; 157.43,34.02 U26.21
  TOP w0.508: U26.29 152.22,33.81 ; 154.18,34.04 154.18,33.78 154.3,33.91 154.3,34.04 154.18,34.04 ; 154.18,34.04 U26.26
  TOP w0.762: 157.43,34.02 158.57,32.87 C158.1 ; 152.22,33.81 151.97,33.55 151.33,33.55 145.39,27.61 ; 148.98,33.79 148.06,32.87 C8.1 ; 159.56,29.06 158.42,29.06 153.92,33.55
  TOP w1.27: 152.4,33.68 152.53,33.68 ; 152.4,33.68 152.4,33.78 ; 152.4,33.68 152.32,33.68 152.22,33.78 152.22,33.81 ; 152.4,33.68 v1(152.4,33.66) ; 152.53,33.68 152.4,33.81 152.4,33.78 ; 152.53,33.68 152.65,33.55 153.92,33.55 ; 152.53,33.68 154.05,33.68 ; v1(146.61,30.73) C2.1 C8.1 ; 153.92,33.55 153.94,33.55 154.07,33.68 ; 153.92,33.55 154.05,33.68 ; 152.4,33.78 152.35,33.78 152.35,33.81 152.22,33.81 ; 145.39,26.42 145.49,26.31 ; 145.39,26.42 C4.1 145.49,26.31 ; 145.39,26.42 145.39,27.69 ; 145.49,26.31 146.48,26.31 ; 152.22,33.81 152.22,33.81 ; 145.39,27.69 C5.1 ; 145.39,27.69 146.61,26.47 FV1.FV ; 146.48,26.31 FV1.FV ; 146.48,26.31 146.61,26.31 FV1.FV ; 159.72,29.06 160.78,27.99 C3.1 ; 159.72,29.06 159.56,29.06 ; 159.72,29.06 160.78,30.12 C162.1 C158.1 ; 159.72,29.06 C7.1 ; 154.05,33.68 154.07,33.68 ; 154.07,33.68 154.18,33.78 ; v1(178.18,122.43) 180.21,120.4 180.21,116.08 178.05,113.92 178.05,76.83 163.19,61.98 J15.3
  BOTTOM w1.27: C139.1 178.61,127.15 178.46,127.15 177.29,125.98 177.44,125.98 177.95,125.48 U24.7 177.95,123.32 178.08,123.19 178.18,123.19 v1(178.18,122.43)
VCC: length 494.5
  TOP w0.508: v1(70.23,73.15) 69.72,72.64 69.72,67.31 v1(61.09,67.31) ; v1(134.75,70.61) 134.75,69.72 136.53,67.94 v1(140.08,67.94) ; v1(77.09,48.89) 77.09,49.78 76.58,50.29 v1(39.88,50.29) ; v1(158.75,55.63) 158.62,55.5 158.62,54.99 156.97,53.34 142.24,53.34 v1(141.99,53.59) ; v1(36.07,77.72) 36.7,77.09 39.12,77.09 39.62,76.58 v1(39.62,75.69) ; v1(125.73,49.78) 115.32,49.78 114.55,50.55 113.79,50.55 113.41,50.93 v1(113.41,51.18) 113.28,51.31 v1(100.84,51.31) ; 76.71,77.22 77.22,77.72 77.22,78.99 77.72,79.5 81.15,79.5 81.28,79.38 83.31,79.38 83.31,79.44 87.03,79.44 87.38,79.04 87.38,77.72 88.01,77.09 v1(92.96,77.09) ; v1(104.65,122.68) 100.97,122.68 100.58,122.3 99.19,122.3 v1(98.55,122.94) ; v1(103.12,132.08) 100.2,132.08 v1(100.08,131.95) ; v1(40.51,121.16) 54.23,121.16 54.74,121.67 v1(54.74,121.92) 55.37,122.56 67.44,122.56 70.1,119.89 80.26,119.89 81.79,118.36 v1(109.09,118.36) 116.33,118.36 v1(116.59,118.11) 126.62,118.11 127.13,118.62 v1(127.13,119.13) FV10.FV 155.32,119.13 155.7,119.51 157.1,119.51 157.61,119 157.61,117.86 158.24,117.22 167.39,117.22 167.89,117.73 v1(167.89,118.36) ; v1(43.69,114.3) 43.69,114.55 42.8,115.44 42.8,116.21 40.51,118.49 v1(40.51,118.87) 32.77,118.87 31.75,117.86 30.99,117.86 30.23,117.09 v1(21.34,117.09)
  BOTTOM w0.254: U20.14 108.74,121.39 109.22,120.9 109.22,118.49 ; U1.2 16.1,98.52 16,98.43 ; U12.2 39.73,74.58 C184.1 ; U5.2 97.95,75.84 97.92,75.82 97.97,75.82 C175.1 ; U10.2 125.53,76.65 v1(125.6,76.58) ; U11.2 70.11,72.14 70.23,72.26 v1(70.23,73.15) ; U2.2 93.68,80.47 93.6,80.39 93.6,79.78 C174.1 ; U19.14 99.32,129.92 99.69,130.3 v1(99.69,130.43) ; C177.1 130.87,76.04 U3.2 ; U15.24 142.76,75.3 v1(142.49,75.56) ; 11.32,77.94 11.32,75.95 C185.1 ; C20.1 54.65,119.75 U16.24 ; v1(97.79,69.47) 97.8,69.48 U7.2 ; U9.2 125.69,68.62 ; v1(68.58,76.58) 68.07,76.58 67.82,76.83 C180.1 67.47,76.87 U8.2 ; U4.2 36.99,79.54 37.15,79.38 38.1,79.38 38.48,79.76 v1(39.12,79.76)
  BOTTOM w0.508: 99.06,124.61 R75.1 ; 99.06,124.61 98.93,124.49 ; 99.06,124.61 99.06,124.46 98.55,123.95 ; R53.1 R52.1 47.75,114.05 45.47,114.05 44.96,113.54 44.07,113.54 43.69,113.92 v1(43.69,114.3) ; v1(114.43,112.52) 114.45,112.55 R76.1 ; 127.1,118.03 127.18,117.96 127.18,116.76 ; 127.1,118.03 127.1,116.84 ; 127.1,118.03 127.1,119.13 v1(127.13,119.13) ; R69.1 34.01,68.22 v1(33.91,68.2) ; R92.1 97.69,124.18 97.92,123.95 98.55,123.95 ; R80.1 140.51,77.8 v1(140.59,77.72) ; 39.78,74.52 C184.1 39.78,75.54 v1(39.62,75.69) ; 39.78,74.52 39.78,74.42 ; 39.78,74.52 39.88,74.42 39.78,74.42 ; C179.1 125.73,75.16 v1(125.73,74.55) ; 39.78,74.42 39.78,73.79 39.88,73.79 v1(39.88,50.29) ; R85.1 113.39,51.16 v1(113.41,51.18) ; 15.94,112.79 R44.1 ; 15.94,112.79 15.94,111.57 R55.1 ; 15.94,112.79 v1(15.49,113.23) ; J16.23 J16.25 J16.27 J16.29 ; v1(116.2,128.02) 116.13,128.02 R79.1 ; 127.1,116.84 127.18,116.76 ; 127.1,116.84 R73.1 ; 127.18,116.76 R78.1 ; v1(100.08,131.95) 99.34,132.69 R82.1 ; v1(167.89,118.36) 167.89,118.49 167.64,118.75 C160.1 167.94,121.16 U28.1 168.17,122.33 168.53,122.68 168.53,125.13 U28.6 ; U17.24 22.08,116.59 21.57,117.09 v1(21.34,117.09) 21.34,118.11 21.68,118.45 22,118.45 22,118.44 C23.1 ; C14.1 139.09,91.47 ; 139.09,91.47 139.09,91.56 139.21,91.69 ; 139.09,91.47 v1(139.09,90.91) U13.24 ; v1(97.79,69.47) 97.84,69.42 C176.1 ; R63.1 140.06,67.92 v1(140.08,67.94) 140.72,67.31 140.72,55.12 L1.1 142.04,53.97 141.99,53.97 v1(141.99,53.59) ; v1(61.09,67.31) 61.06,67.34 R68.1 ; U22.14 v1(75.51,124.64) ; v1(116.59,118.11) 116.59,117.45 117.35,116.69 U27.14 ; v1(98.93,76.2) 98.81,76.07 98.81,75.97 98.68,75.84 C175.1 ; 109.22,118.49 v1(109.09,118.36) R81.1 ; 98.55,123.95 v1(98.55,122.94) ; R89.1 158.95,55.83 v1(158.75,55.63) 158.65,55.52 C133.1 ; v1(77.09,48.89) 77.09,48.95 R84.1 R83.1 ; C174.1 93.6,79.65 93.6,79.63 92.96,78.99 v1(92.96,77.09) ; v1(134.75,70.61) 134.75,70.66 R62.1 ; C183.1 v1(16,100.97) ; v1(70.23,73.15) 70.26,73.13 C181.1 ; 125.69,68.62 FV2.FV C178.1 v1(125.73,49.78) v1(125.73,33.02) ; C182.1 36.12,78.28 36.07,78.23 v1(36.07,77.72) ; C27.1 40.54,121.54 40.51,121.54 v1(40.51,121.16) v1(40.51,118.87) ; C20.1 v1(54.71,120.93) 54.71,121.92 v1(54.74,121.92) ; U14.16 v1(51.82,120.65) ; v1(12.19,75.56) 11.81,75.95 11.32,75.95 ; C62.1 v1(143.56,68.96) ; v1(117.07,131.47) R70.1 ; C177.1 v1(130.91,75.21) ; v1(104.65,122.68) 104.62,122.71 R77.1 104.62,124.46 104.52,124.46 103.5,125.48 103.5,127.25 103.48,127.25 R74.1 R72.1 R71.1 103.48,131.47 103.12,131.83 v1(103.12,132.08) ; v1(114.38,115.57) R93.1 ; v1(124.71,32) R86.1
A0: length 246.3
  TOP w0.127: 58.17,114.55 58.17,115.32 54.99,118.49 v1(53.85,118.49) ; 58.17,114.55 58.67,115.06 v1(79.38,115.06) 80.39,115.06 80.64,115.32 107.7,115.32 108.97,116.59 119.51,116.59 120.27,115.82 154.18,115.82 155.7,114.3 v1(156.72,114.3) ; 58.17,114.55 v1(58.17,113.28) ; v1(58.42,109.47) 58.17,109.73 53.21,109.73 51.18,111.76 43.43,111.76 42.8,112.4 41.53,112.4 38.86,109.73 33.78,109.73 33.66,109.85 32.13,109.85 32,109.73 30.99,109.73 30.61,109.35 v1(26.42,109.35) ; 146.61,76.66 145.92,77.34 v1(143.13,77.34) ; 146.61,76.66 v1(146.61,70.66) ; 146.61,76.66 146.63,76.63 150.57,76.63 150.88,76.33 154.43,76.33 154.56,76.45 v1(156.97,76.45)
  BOTTOM w0.127: U22.1 80.9,124.08 79.38,122.56 v1(79.38,115.06) ; 57.91,113.43 58.42,112.93 v1(58.42,109.47) ; 57.91,113.43 U16.10 ; 57.91,113.43 58.04,113.43 58.17,113.31 v1(58.17,113.28) ; v1(53.85,118.49) 53.85,125.2 ; 53.85,125.2 53.97,125.33 53.97,129.67 52.49,131.14 52.49,134.53 55.12,137.16 60.31,137.16 J16.39 ; 53.85,125.2 U14.9 ; v1(156.97,76.45) 156.97,102.23 156.72,102.49 v1(156.72,114.3) ; U15.10 146.48,70.8 146.61,70.68 v1(146.61,70.66) ; 143,77.34 v1(143.13,77.34) ; 26.26,109.35 v1(26.42,109.35)
A0N: length 34.7
  TOP w0.127: v1(84.45,129.16) 84.33,129.03 75.31,129.03 74.8,129.54 62.1,129.54 61.34,130.3 v1(61.21,130.3)
  BOTTOM w0.127: J16.5 61.39,130.3 v1(61.21,130.3) ; U22.2 81.42,123.44 82.68,123.44 84.45,125.22 v1(84.45,129.16)
A1: length 258.5
  TOP w0.127: v1(137.16,93.85) 153.29,93.85 153.8,93.34 153.8,84.2 153.54,83.95 141.86,83.95 v1(141.6,84.2) v1(142.62,84.2) ; 42.8,113.79 42.42,114.17 v1(42.16,114.17) ; 42.8,113.79 42.29,113.79 39.37,110.87 32.26,110.87 31.37,109.98 25.65,109.98 25.15,109.47 v1(25.15,109.22) ; 42.8,113.79 44.07,113.79 44.32,114.05 44.32,114.81 44.58,115.06 45.47,115.06 46.48,114.05 54.1,114.05 55.88,112.27 v1(57.91,112.27) 58.17,112.52 64.9,112.52 65.41,113.03 66.17,113.03 66.93,112.27 v1(79.88,112.27) 80.01,112.4 110.74,112.4 112.55,114.2 119.89,114.2 120.8,113.28 124.59,113.28 125.48,114.17 v1(137.16,114.17) ; v1(53.72,137.54) 61.85,137.54 v1(61.98,137.41) ; v1(144.02,75.08) 146,75.08 146.1,74.98 146.1,69.85 146.2,69.75 v1(146.43,69.75)
  BOTTOM w0.127: v1(144.02,75.08) 144.12,75.08 144.12,75.67 144.02,75.77 144.02,81.28 142.62,82.68 v1(142.62,84.2) ; 146.3,69.75 v1(146.43,69.75) ; J16.40 62.59,136.8 v1(61.98,137.41) ; v1(137.16,93.85) v1(137.16,114.17) ; v1(53.72,137.54) 48.13,131.95 48.13,128.02 48.51,127.63 48.51,127 ; 141.59,84.61 141.6,84.61 v1(141.6,84.2) 141.58,84.23 141.59,84.23 141.59,84.61 ; 141.59,84.61 U13.11 141.59,84.96 ; v1(79.88,112.27) 79.88,122.3 80.39,122.81 81.38,122.81 U22.3 ; v1(42.16,114.17) 42.42,114.43 42.42,126.11 43.31,127 48.51,127 ; v1(57.91,112.27) 57.53,112.27 57.15,112.65 U16.11 ; 25.15,109.73 v1(25.15,109.22) ; 48.51,127 48.51,125.86 48.89,125.48 48.89,124.84 48.6,124.55 U14.7
A1N: length 31.7
  TOP w0.127: v1(61.47,124.84) 61.98,124.33 71.63,124.33 72.26,123.7 78.87,123.7 80.39,122.17 v1(82.93,122.17)
  BOTTOM w0.127: J16.6 62.19,129.87 61.47,129.16 v1(61.47,124.84) ; U22.4 81.45,122.17 v1(82.93,122.17)
A2: length 315.7
  TOP w0.127: v1(138.43,84.2) 140.72,81.91 145.03,81.91 146.81,83.69 153.67,83.69 154.05,84.07 154.05,94.23 153.54,94.74 v1(135.51,94.74) ; v1(139.7,77.47) 139.9,77.47 140.08,77.29 140.13,77.29 141.35,76.07 141.35,73.15 140.97,72.77 140.97,70.36 v1(141.48,69.85) ; v1(45.59,123.95) 45.59,124.08 45.57,124.1 43.05,124.1 42.52,123.57 40.16,123.57 39.62,124.1 27.81,124.1 27.3,123.6 27.3,123.57 27.18,123.44 8.13,123.44 7.62,122.94 7.62,108.84 8.13,108.33 16.13,108.33 17.02,109.22 20.57,109.22 21.46,110.11 v1(21.46,110.24) ; v1(49.66,109.85) v1(42.93,109.85) ; v1(132.46,114.68) 125.35,114.68 124.33,113.66 121.03,113.66 120.14,114.55 112.14,114.55 110.87,113.28 v1(83.69,113.28) 64.77,113.28 64.26,112.78 57.53,112.78 53.72,116.59 v1(51.94,116.59)
  BOTTOM w0.127: v1(45.59,123.95) 45.85,123.95 45.85,123.9 45.97,123.9 ; v1(49.66,109.85) 51.43,111.63 52.32,111.63 52.83,112.14 52.83,112.81 52.96,112.93 U16.14 ; 142.17,70.3 141.48,70.3 v1(141.48,69.85) ; v1(135.51,94.74) 135.25,95 135.25,111.89 v1(132.46,114.68) ; v1(51.94,116.59) 47.12,116.59 46.61,117.09 ; 45.97,123.9 45.97,119.89 46.61,119.25 46.61,117.09 ; 45.97,123.9 U14.6 48.01,123.9 48.01,123.95 48.13,124.08 50.29,124.08 50.8,124.59 50.8,130.68 52.07,131.95 52.07,134.62 55.5,138.05 62.48,138.05 63.39,137.14 J16.41 ; U22.5 83.24,121.48 83.69,121.03 v1(83.69,113.28) ; 46.61,117.09 46.35,116.84 43.43,116.84 42.93,116.33 v1(42.93,109.85) ; v1(139.7,77.47) 139.95,77.47 139.95,82.68 v1(138.43,84.2) 138.18,84.45 138.18,84.99 ; 21.08,111.37 U17.14 21.08,110.49 21.46,110.11 v1(21.46,110.24)
A2N: length 56.8
  TOP w0.127: v1(62.86,130.43) 62.86,130.56 63.63,129.79 75.06,129.79 75.44,129.41 83.69,129.41 84.07,129.79 v1(85.98,129.79)
  BOTTOM w0.127: v1(62.86,130.43) 62.99,130.56 J16.7 ; U22.6 81.46,120.78 82.93,120.78 83.44,120.27 83.44,119.38 83.31,119.25 83.31,114.17 82.93,113.79 82.93,112.9 83.44,112.4 84.33,112.4 84.58,112.65 84.58,113.54 84.07,114.05 84.07,123.95 85.98,125.86 v1(85.98,129.79)
